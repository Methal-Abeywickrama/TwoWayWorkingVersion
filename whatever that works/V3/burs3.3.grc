options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: BUFFER_SIZE
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: MIN_TAIL
  id: variable
  parameters:
    comment: |-
      Bytes after the CRC so the modulator's
      RRC filter (~22 symbols) has sent the
      last bit before the gate blanks.
    value: '8'
  states: {}
- name: MY_ID
  id: variable
  parameters:
    value: '1'
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: TX_BUFFER
  id: variable
  parameters:
    comment: |-
      Pluto TX buffer (samples). Must be a
      multiple of 32 (8 bits x sps). The framer
      fills every burst to whole buffers.
    value: BUFFER_SIZE * sps
  states: {}
- name: TX_HOLD_MS
  id: variable
  parameters:
    comment: |-
      Extra wait (ms) after the queued
      buffers before TX off
    value: '5.0'
  states: {}
- name: TX_OFF_ATTEN
  id: variable
  parameters:
    comment: TX attenuation when off (dB, max 89.75)
    value: '89.75'
  states: {}
- name: TX_OFF_MODE
  id: variable
  parameters:
    comment: '''atten'' | ''lo'' | ''both'' | ''none'''
    value: '''atten'''
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    modulus: '2'
    step_size: '.01'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.03'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: max_payload_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: power_threshold
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '0'
    value: '-35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.020'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '15'
    sps: '2'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '0.05'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Burst Packet Framer TX (buffer-aligned)

      Same frame format as before, so the deframer and the other PC are unchanged:
        [preamble][1A CF FC 1D][len:2][dest:1][msg_id:1][rep:1][n_reps:1][payload][CRC32:4][tail][pad]

        tail  min_tail bytes (default 8). The Constellation Modulator's pulse-shaping filter
              delays the signal by about 22 symbols (88 samples at sps=4), so the last CRC bits
              only leave the modulator once a few more bytes have gone in after them.
        pad   fills the burst up to a whole number of Pluto TX buffers, so the sink pushes the
              whole burst at once and nothing is left waiting in the sink.

              samples per byte = (8 / bits_per_symbol) * sps         (BPSK, sps 4: 32)
              pad unit (bytes) = tx_buffer / samples per byte          (4096 samples: 128 bytes)
              tx_buffer must be the Pluto sink's buffer size and a multiple of samples per byte.

      Every burst PDU carries this metadata. PDU to Tagged Stream turns each entry into a stream
      tag on the burst's first byte; after the modulator the tags sit on the burst's first sample:
        tx_sob      True
        burst_data  number of samples that carry the frame (preamble ... tail)
        burst_len   number of samples in the whole burst (always n * tx_buffer)
      The TX Burst Gate block reads these tags, blanks the pad and switches the transmitter off.
      """
      import zlib
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      HDR_BYTES = 6


      class PacketFramerTX(gr.basic_block):
          def __init__(self, peer_id=1, preamble_len=512, repeat_count=1, max_payload_len=8192,
                       preamble_byte=0xFF, tx_buffer=4096, sps=4, bits_per_symbol=1,
                       min_tail=8, pad_byte=0x00):
              gr.basic_block.__init__(self, name="Packet Framer TX (Buffer-aligned Burst)",
                                      in_sig=None, out_sig=None)
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = min(int(max_payload_len), 0xFFFF)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.tx_buffer = int(tx_buffer)
              self.sps = int(sps)
              self.bits_per_symbol = int(bits_per_symbol)
              self.min_tail = max(0, int(min_tail))
              self.pad_byte = int(pad_byte) & 0xFF
              self._msg_id = 0
              self._unit()                      # fail early (in GRC) on a bad tx_buffer / sps

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          # samples per byte and pad unit in bytes (re-read every frame, so GRC callbacks work)
          def _unit(self):
              if self.bits_per_symbol not in (1, 2, 4, 8):
                  raise ValueError("bits_per_symbol must be 1, 2, 4 or 8")
              spb = (8 // self.bits_per_symbol) * self.sps
              if self.tx_buffer <= 0 or self.tx_buffer % spb:
                  raise ValueError(f"tx_buffer ({self.tx_buffer}) must be a positive multiple of "
                                   f"{spb} samples (8/bits_per_symbol * sps)")
              return spb, self.tx_buffer // spb

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def build_burst(self, payload, msg_id, rep, n_reps):
              """Returns (burst bytes, data samples, total samples)."""
              spb, unit = self._unit()
              header = len(payload).to_bytes(2, "big") + bytes([self.peer_id, msg_id, rep, n_reps])
              crc = zlib.crc32(header + payload).to_bytes(4, "big")
              body = (bytes([self.preamble_byte]) * self.preamble_len + SYNC_WORD + header + payload
                      + crc + bytes(self.min_tail))
              pad = (-len(body)) % unit
              burst = body + bytes([self.pad_byte]) * pad
              return burst, len(body) * spb, len(burst) * spb

          def handle_msg(self, msg):
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return
              if not payload:
                  return
              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[:self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              for rep in range(n_reps):
                  burst, data_samps, total_samps = self.build_burst(payload, msg_id, rep, n_reps)
                  if rep == 0:
                      nbuf = total_samps // self.tx_buffer
                      print(f"[TX] msg #{msg_id} (to peer {self.peer_id}): {len(payload)} B payload, "
                            f"burst {len(burst)} B = {nbuf} x {self.tx_buffer} samples "
                            f"(signal {data_samps}, blank {total_samps - data_samps}), "
                            f"{n_reps} burst(s)", flush=True)
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("tx_sob"), pmt.PMT_T)
                  meta = pmt.dict_add(meta, pmt.intern("burst_data"), pmt.from_long(data_samps))
                  meta = pmt.dict_add(meta, pmt.intern("burst_len"), pmt.from_long(total_samps))
                  vec = pmt.init_u8vector(len(burst), list(burst))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
    bits_per_symbol: '1'
    max_payload_len: '8192'
    min_tail: MIN_TAIL
    pad_byte: '0'
    peer_id: 1-MY_ID
    preamble_byte: '0xFF'
    preamble_len: '128'
    repeat_count: '5'
    sps: sps
    tx_buffer: TX_BUFFER
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Fast Burst Packet Deframer RX
      - Vectorized NumPy sliding-window sync detection (fast C execution, minimal GIL load)
      - Positive correlation search only (180-deg phase ambiguity resolved upstream by diff decoder)
      - 1-bit false sync backtracking (prevents dropped frames on noise triggers)
      - Full CRC32 verification over header + payload
      - Destination address filtering: drops frames where dest_id != peer_id
      - Message deduplication: displays payload once per msg_id, then logs burst statistics
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      HDR_BYTES = 6  # len (2B) + dest_id (1B) + msg_id (1B) + rep (1B) + n_reps (1B)


      class PacketDeframerRX(gr.sync_block):
          def __init__(self, peer_id=1, max_bit_errors=2, max_payload_len=1024, bit_rate=375000):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX (Fast Burst)",
                  in_sig=[np.uint8],
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.bit_rate = float(bit_rate)

              # Bipolar template (+1 / -1) for correlation
              self._sync = np.unpackbits(np.frombuffer(SYNC_WORD, np.uint8)).astype(np.int16) * 2 - 1
              self._buf = np.zeros(0, dtype=np.uint8)

              self.n_sync = 0
              self.n_ok = 0
              self.n_crc_fail = 0
              self.n_bad_len = 0

              self._bits_total = 0
              self._bits_at_last_ok = 0
              self._cur_id = None
              self._cur_reps = set()
              self._cur_nreps = 0

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("text_out"))

          def _flush_summary(self):
              if self._cur_id is not None:
                  got, n = len(self._cur_reps), self._cur_nreps
                  loss = 100.0 * (n - got) / max(n, 1)
                  print(f"[RX] msg #{self._cur_id}: {got}/{n} bursts OK (Loss: {loss:.0f}%)", flush=True)
              self._cur_id = None
              self._cur_reps = set()

          def _deliver(self, header, payload):
              dest_id, msg_id, rep, n_reps = header[2], header[3], header[4], header[5]
              if msg_id != self._cur_id:
                  self._flush_summary()
                  self._cur_id, self._cur_nreps = msg_id, n_reps
                  text = payload.decode("utf-8", errors="replace")
                  print("\n" + "=" * 40, flush=True)
                  print(f"[RX RECEIVED] #{msg_id}: {text}", flush=True)
                  print("=" * 40 + "\n", flush=True)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dest_id))
                  meta = pmt.dict_add(meta, pmt.intern("msg_id"), pmt.from_long(msg_id))
                  meta = pmt.dict_add(meta, pmt.intern("n_reps"), pmt.from_long(n_reps))
                  vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
                  self.message_port_pub(pmt.intern("text_out"), pmt.intern(text))

              self._cur_reps.add(rep)
              self._bits_at_last_ok = self._bits_total

          def work(self, input_items, output_items):
              bits = input_items[0] & 1
              self._bits_total += len(bits)
              self._buf = np.concatenate((self._buf, bits)) if len(self._buf) else bits.copy()

              # Flush transmission stats once channel has been quiet for > 0.5s of air time
              if self._cur_id is not None and self._bits_total - self._bits_at_last_ok > 0.5 * self.bit_rate:
                  self._flush_summary()

              thr = 32 - 2 * self.max_bit_errors
              hdr_bits = 32 + HDR_BYTES * 8

              while True:
                  buf = self._buf
                  if len(buf) < hdr_bits:
                      return len(bits)

                  # Fast matrix dot product over 32-bit window (only positive peaks)
                  pm = buf.astype(np.int16) * 2 - 1
                  corr = np.lib.stride_tricks.sliding_window_view(pm, 32) @ self._sync
                  cand = np.flatnonzero(corr >= thr)

                  if cand.size == 0:
                      self._buf = buf[-31:].copy()  # Preserve trailing bits that might begin a sync word
                      return len(bits)

                  i = int(cand[0])

                  if len(buf) < i + hdr_bits:
                      self._buf = buf[i:].copy()  # Await complete header bits
                      return len(bits)

                  header = np.packbits(buf[i + 32 : i + hdr_bits]).tobytes()
                  length = int.from_bytes(header[:2], "big")

                  if length == 0 or length > self.max_payload_len:
                      self.n_bad_len += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync
                      continue

                  end = i + 32 + (HDR_BYTES + length + 4) * 8
                  if len(buf) < end:
                      self._buf = buf[i:].copy()  # Await complete frame body bits
                      return len(bits)

                  body = np.packbits(buf[i + 32 : end]).tobytes()
                  hdr, payload, rx_crc = body[:HDR_BYTES], body[HDR_BYTES : HDR_BYTES + length], body[-4:]
                  self.n_sync += 1

                  if zlib.crc32(hdr + payload) == int.from_bytes(rx_crc, "big"):
                      dest_id = hdr[2]
                      if dest_id == self.peer_id:
                          self.n_ok += 1
                          self._deliver(hdr, payload)
                      # Frame addressed to another peer: discard silently
                      self._buf = buf[end:].copy()  # Advance past valid frame
                  else:
                      self.n_crc_fail += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync

              return len(bits)
    bit_rate: '375000'
    max_bit_errors: '1'
    max_payload_len: max_payload_len
    peer_id: MY_ID
  states: {}
- name: epy_block_txgate
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: TX Burst Gate (place between the Constellation Modulator and the
      PlutoSDR Sink). It acts on the burst tags of the buffer-aligned framer:

        tx_sob + burst_data + burst_len   (on the first sample of every burst)

      1. Before the first sample of a burst is passed on, the transmitter is switched ON
         (synchronously, so no burst sample can reach the radio while it is still off).
      2. The samples after `burst_data` (the pad that fills the last Pluto buffer) are set to 0,
         with a short ramp, so nothing is radiated there. The burst stays n * tx_buffer samples
         long, so the sink still sends it out immediately.
      3. A sample-accurate `tx_eob` tag is put on the last signal sample (plus `tx_sob` on the
         first one) for anything downstream that understands them.
      4. When `tx_eob` passes, the transmitter is switched OFF after `hold` seconds:
             hold = (kernel_buffers + 3) * tx_buffer / samp_rate + hold_ms / 1000
         That covers every sample that can still be queued between this block and the antenna
         (GNU Radio buffer ~2 x tx_buffer, the sink's own buffer, libiio's kernel buffers).
         A new burst cancels a pending OFF. GNU Radio never says when the radio has really sent
         the last sample, so this delay is an upper bound; during it only zeros are sent.

      mode (how "off" is done, through libiio on the same URI as the Pluto sink):
        'atten'  TX attenuation -> off_atten (89.75 dB = the AD9361 maximum); on -> on_atten
                 (keep on_atten = the Pluto sink's attenuation, e.g. CH_GAIN)
        'lo'     power down the TX LO (no carrier/LO leakage at all); power up again for a burst.
                 The 512+ byte preamble covers the LO lock time.
        'both'   both of the above
        'none'   only blanking + tags (no radio control)
      Needs the libiio Python bindings (`import iio`; Ubuntu/Debian: sudo apt install python3-libiio).
      Without them it prints a warning and keeps working in 'none' mode.

      If bursts arrive WITHOUT tags (e.g. a Tag Gate in front of this block), the gate switches the
      TX on as soon as non-zero samples show up and off again after `hold`, and warns once.
      """
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr

      AD9361_MAX_ATTEN = 89.75


      class TxBurstGate(gr.sync_block):
          def __init__(self, uri="ip:192.168.1.10", samp_rate=1.5e6, tx_buffer=4096,
                       on_atten=20.0, off_atten=89.75, mode="atten", kernel_buffers=4,
                       hold_ms=5.0, ramp=64, verbose=True):
              gr.sync_block.__init__(self, name="TX Burst Gate",
                                     in_sig=[np.complex64], out_sig=[np.complex64])
              self.set_tag_propagation_policy(gr.TPP_DONT)   # tags are re-made below, sample exact
              self.uri = str(uri)
              self.samp_rate = float(samp_rate)
              self.tx_buffer = int(tx_buffer)
              self.on_atten = float(on_atten)
              self.off_atten = float(off_atten)
              self.mode = str(mode).lower()
              self.kernel_buffers = int(kernel_buffers)
              self.hold_ms = float(hold_ms)
              self.ramp = max(0, int(ramp))
              self.verbose = bool(verbose)
              if self.mode not in ("atten", "lo", "both", "none"):
                  raise ValueError("mode must be 'atten', 'lo', 'both' or 'none'")

              self._lock = threading.RLock()
              self._bursts = []          # [start, data_end, end, eob_done] absolute sample offsets
              self._timer = None
              self._gen = 0              # bumped by every burst start; a stale OFF timer sees it
              self._on = None            # None = unknown, True = transmitting, False = off
              self._phy = None
              self._tx_chans = []
              self._lo = None
              self._warned_untagged = False
              self.n_bursts = 0
              self.n_off = 0

          # ------------------------------------------------------------- radio control
          def _hold_s(self):
              return (self.kernel_buffers + 3) * self.tx_buffer / self.samp_rate + self.hold_ms / 1000.0

          def _open(self):
              if self.mode == "none":
                  return
              try:
                  import iio
              except ImportError:
                  print("[TXGATE] libiio Python bindings not found (sudo apt install python3-libiio) "
                        "- TX on/off control DISABLED, blanking + tags still work", flush=True)
                  self.mode = "none"
                  return
              try:
                  ctx = iio.Context(self.uri) if self.uri else iio.Context()
                  phy = ctx.find_device("ad9361-phy")
                  if phy is None:
                      raise RuntimeError("no ad9361-phy device at " + self.uri)
                  self._ctx, self._phy = ctx, phy
                  self._tx_chans = [c for c in (phy.find_channel("voltage0", True),
                                                phy.find_channel("voltage1", True))
                                    if c is not None and "hardwaregain" in c.attrs]
                  self._lo = phy.find_channel("altvoltage1", True)        # TX_LO
                  if self._lo is not None and "powerdown" not in self._lo.attrs:
                      self._lo = None
                  print(f"[TXGATE] radio control on {self.uri}: mode={self.mode}, "
                        f"off={self.off_atten} dB, hold={self._hold_s() * 1000:.1f} ms", flush=True)
              except Exception as e:
                  print(f"[TXGATE] could not open {self.uri} for TX control ({e}) - "
                        "TX on/off control DISABLED, blanking + tags still work", flush=True)
                  self.mode = "none"

          def _write(self, chan, attr, value):
              try:
                  chan.attrs[attr].value = value
              except Exception as e:
                  print(f"[TXGATE] write {attr}={value} failed: {e}", flush=True)

          def _set_tx(self, on):
              """Switch the transmitter on/off. Caller holds self._lock."""
              if self._on is on:
                  return
              t0 = time.time()
              if self.mode in ("lo", "both") and self._lo is not None:
                  self._write(self._lo, "powerdown", "0" if on else "1")
              if self.mode in ("atten", "both"):
                  att = self.on_atten if on else min(abs(self.off_atten), AD9361_MAX_ATTEN)
                  for c in self._tx_chans:
                      self._write(c, "hardwaregain", f"{-abs(att):.2f}")
              self._on = on
              if not on:
                  self.n_off += 1
              if self.verbose and self.mode != "none" and self.n_bursts <= 3:
                  print(f"[TXGATE] TX {'ON ' if on else 'OFF'} ({(time.time() - t0) * 1000:.1f} ms)",
                        flush=True)

          def _off_later(self, delay):
              with self._lock:
                  if self._timer is not None:
                      self._timer.cancel()
                  gen = self._gen
                  self._timer = threading.Timer(delay, self._off_timer, args=[gen])
                  self._timer.daemon = True
                  self._timer.start()

          def _off_timer(self, gen):
              with self._lock:
                  if gen == self._gen and not self._bursts_pending():
                      self._set_tx(False)

          def _bursts_pending(self):
              # a burst whose signal part has not fully passed yet keeps the TX on
              return any(not b[3] for b in self._bursts)

          def start(self):
              self._open()
              with self._lock:
                  self._set_tx(False)          # idle = off
              return True

          def stop(self):
              with self._lock:
                  if self._timer is not None:
                      self._timer.cancel()
                  if self.mode != "none":
                      # leave the radio as the Pluto sink configured it
                      self._on = None
                      self._set_tx(True)
              return True

          # ------------------------------------------------------------- stream
          def _ramp(self, n):
              return (0.5 - 0.5 * np.cos(np.pi * (np.arange(n) + 0.5) / n)).astype(np.float32)

          def work(self, input_items, output_items):
              inp, out = input_items[0], output_items[0]
              n = len(inp)
              base = self.nitems_read(0)
              out[:] = inp

              # 1) new bursts from the framer's tags (all three sit on the burst's first sample)
              found = {}
              for t in self.get_tags_in_window(0, 0, n):
                  key = pmt.symbol_to_string(t.key)
                  if key in ("burst_data", "burst_len", "tx_sob"):
                      d = found.setdefault(t.offset, {})
                      if key != "tx_sob":
                          d[key] = pmt.to_long(t.value)
              for off in sorted(found):
                  d = found[off]
                  if "burst_len" not in d:
                      continue
                  data = min(int(d.get("burst_data", d["burst_len"])), int(d["burst_len"]))
                  with self._lock:
                      self._gen += 1                       # cancels any pending OFF
                      if self._timer is not None:
                          self._timer.cancel()
                          self._timer = None
                      self._set_tx(True)                   # ON before the first sample leaves here
                      self._bursts.append([off, off + data, off + int(d["burst_len"]), False])
                      self.n_bursts += 1
                  if off % self.tx_buffer and self.verbose:
                      print(f"[TXGATE] warning: burst starts at sample {off}, not on a "
                            f"{self.tx_buffer}-sample boundary (tx_buffer must equal the sink's "
                            "buffer size, and nothing else may feed the modulator)", flush=True)
                  self.add_item_tag(0, off, pmt.intern("tx_sob"), pmt.PMT_T)

              # 2) blank the pad, ramp the edges, tag the end, schedule OFF
              r = self._ramp(self.ramp) if self.ramp else None
              done = []
              with self._lock:
                  tagged = bool(self._bursts)
                  for b in self._bursts:
                      start, dend, end, eob = b
                      lo, hi = base, base + n
                      if r is not None:
                          # ramp up over the first `ramp` samples, ramp down over the last `ramp` signal samples
                          for (a, w) in ((start, r), (dend - self.ramp, r[::-1])):
                              s, e = max(a, lo), min(a + len(w), hi)
                              if s < e:
                                  out[s - lo:e - lo] *= w[s - a:e - a]
                      s, e = max(dend, lo), min(end, hi)
                      if s < e:
                          out[s - lo:e - lo] = 0
                      if not eob and lo <= dend - 1 < hi:
                          self.add_item_tag(0, dend - 1, pmt.intern("tx_eob"), pmt.PMT_T)
                          b[3] = True
                          if self.mode != "none":
                              self._off_later(self._hold_s())
                      if end <= hi and b[3]:
                          done.append(b)
                  for b in done:
                      self._bursts.remove(b)

              # 3) safety net: signal without tags (tags stripped upstream)
              if not tagged and self.mode != "none" and np.any(inp != 0):
                  if not self._warned_untagged:
                      print("[TXGATE] signal without burst tags (is a Tag Gate in front of this "
                            "block?) - switching TX on for it, no blanking", flush=True)
                      self._warned_untagged = True
                  with self._lock:
                      self._gen += 1
                      self._set_tx(True)
                  self._off_later(self._hold_s())
              return n
    comment: |-
      TX Burst Gate: TX on before each burst,
      blank pad after tx_eob, TX off after hold.
      mode TX_OFF_MODE: 'atten' | 'lo' | 'both' | 'none'
    hold_ms: TX_HOLD_MS
    kernel_buffers: '4'
    mode: TX_OFF_MODE
    off_atten: TX_OFF_ATTEN
    on_atten: CH_GAIN
    ramp: '64'
    samp_rate: samp_rate
    tx_buffer: TX_BUFFER
    uri: ADDR
    verbose: 'True'
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: '1500000'
    buffer_size: BUFFER_SIZE
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(1.27e9)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1500000'
    bbdc: 'True'
    buffer_size: BUFFER_SIZE
    filter_source: '''Auto'''
    frequency: int(1.25e9)
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'Rx: Power squelch before AGC, parameters changed, new sink added to observe Rx power'
  states: {}
- name: note_1
  id: note
  parameters:
    note: To observe signal power
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0'
    ymin: '-55'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', blocks_copy_1_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_1, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_5_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', epy_block_txgate, '0']
- [digital_constellation_modulator_0_1, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_txgate, '0', iio_pluto_sink_0_0, '0']
- [epy_block_txgate, '0', virtual_sink_5_0, '0']
- [iio_pluto_source_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', blocks_copy_0_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
