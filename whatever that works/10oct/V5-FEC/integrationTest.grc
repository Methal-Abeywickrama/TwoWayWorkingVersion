options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: os.environ.get('SDR_URI', 'ip:192.168.1.10')
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: BUFFER_SIZE
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: FEC
  id: variable
  parameters:
    comment: |-
      0 = no FEC
      15 = Hamming(15,11)
      31 = Hamming(31,26)
    value: '31'
  states: {}
- name: FILTER_BW
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: MY_ID
  id: variable
  parameters:
    comment: 'Frequency plan: 0 -> TX 1250 / RX 1270 MHz, 1 -> TX 1270 / RX 1250 MHz. Env MY_ID, else derived from TL_LOCAL_ADDR (1 -> 0, anything else -> 1).'
    value: int(os.environ.get('MY_ID', '0' if tl_local_addr == 1 else '1'))
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: RC_PULSE
  id: variable
  parameters:
    value: np.sinc(RC_X)*np.cos(np.pi*alpha*RC_X)/(1-(2*alpha*RC_X)**2)
  states: {}
- name: RC_X
  id: variable
  parameters:
    value: np.arange(-8, 9)/2.0
  states: {}
- name: RX_AMP
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: RX_FREQ
  id: variable
  parameters:
    value: TX_FREQ_A if MY_ID == 1 else TX_FREQ_B
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: TRAIN_BITS
  id: variable
  parameters:
    value: np.unpackbits(np.frombuffer(bytes([0xF8, 0xDD, 0x42, 0x58]), np.uint8))
  states: {}
- name: TRAIN_REF
  id: variable
  parameters:
    value: list(map(complex, RX_AMP*np.convolve(np.kron(TRAIN_SYMS, [1, 0]), RC_PULSE)[8:8+2*len(TRAIN_SYMS)-1]))
  states: {}
- name: TRAIN_SYMS
  id: variable
  parameters:
    value: list(map(complex, 1 - 2*np.bitwise_xor.accumulate(TRAIN_BITS).astype(int)))
  states: {}
- name: TX_FREQ
  id: variable
  parameters:
    value: TX_FREQ_A if MY_ID == 0 else TX_FREQ_B
  states: {}
- name: TX_FREQ_A
  id: variable
  parameters:
    value: int(1250e6)
  states: {}
- name: TX_FREQ_B
  id: variable
  parameters:
    value: int(1270e6)
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    step_size: '0.5'
    type: nlms
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: corr_thr
  id: variable_qtgui_range
  parameters:
    comment: Normalized correlation threshold (0..1). Random data ~0.1-0.25, real train word ~0.8-1.0.
    start: '0.3'
    step: '0.01'
    stop: '0.98'
    value: '0.7'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.06'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: margin_db
  id: variable_qtgui_range
  parameters:
    label: Squelch margin over noise (dB)
    start: '2'
    step: '0.5'
    stop: '20'
    value: '6'
  states: {}
- name: max_payload_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: power_threshold
  id: variable_function_probe
  parameters:
    block_id: epy_noise
    comment: Automatic squelch threshold (dB) from the noise-floor tracker
    function_name: level
    poll_rate: '5'
    value: '-40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.020'
  states: {}
- name: tl_local_addr
  id: variable
  parameters:
    value: int(os.environ.get('TL_LOCAL_ADDR', '1'))
  states: {}
- name: tl_local_addr_0
  id: variable
  parameters:
    value: int(os.environ.get('TL_LOCAL_ADDR', '1'))
  states: {}
- name: tl_local_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_LOCAL_PORT', '1'))
  states: {}
- name: tl_m
  id: variable
  parameters:
    value: int(os.environ.get('TL_M', '4'))
  states: {}
- name: tl_max_retries
  id: variable
  parameters:
    value: int(os.environ.get('TL_MAX_RETRIES', '10'))
  states: {}
- name: tl_mtu
  id: variable
  parameters:
    value: int(os.environ.get('TL_MTU', '200'))
  states: {}
- name: tl_peer_addr
  id: variable
  parameters:
    value: int(os.environ.get('TL_PEER_ADDR', '2'))
  states: {}
- name: tl_peer_addr_0
  id: variable
  parameters:
    value: int(os.environ.get('TL_PEER_ADDR', '2'))
  states: {}
- name: tl_role
  id: variable
  parameters:
    value: os.environ.get('TL_ROLE', 'initiator')
  states: {}
- name: tl_rto_ms
  id: variable
  parameters:
    value: int(os.environ.get('TL_RTO_MS', '2000'))
  states: {}
- name: tl_zmq_rx_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_ZMQ_RX_PORT', '52002'))
  states: {}
- name: tl_zmq_tx_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_ZMQ_TX_PORT', '52001'))
  states: {}
- name: train_delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '12'
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '5e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_2
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_corr
  id: blocks_tag_debug
  parameters:
    filter: '"corr_est"'
    name: corr_est
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '32'
    lengthtagname: '''packet_len'''
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: 'False'
    alg: adpt_alg
    num_taps: '7'
    sps: '2'
    training_sequence: TRAIN_SYMS
    training_start_tag: '"corr_est"'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '0.05'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import struct, pmt
      from gnuradio import gr

      HDR_FMT  = ">BBBBBBHHQ"
      HDR_SIZE = struct.calcsize(HDR_FMT)  # 18

      PKT_STR   = {0x01:"SYN", 0x02:"SYN_ACK", 0x03:"DATA",
                   0x04:"ACK", 0x05:"FIN", 0x06:"FIN_ACK"}
      MEDIA_STR = {0x01:"text", 0x02:"image", 0x03:"audio"}


      class blk(gr.sync_block):
          """Block 1: RX Header Parser -- stateless 18-byte binary header deserializer."""

          def __init__(self):
              gr.sync_block.__init__(self, name='RX Header Parser',
                                     in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg): return
              in_meta = pmt.car(msg)
              in_data = pmt.cdr(msg)
              if not pmt.is_u8vector(in_data): return
              raw = bytes(pmt.u8vector_elements(in_data))
              if len(raw) < HDR_SIZE: return
              fields   = struct.unpack_from(HDR_FMT, raw)
              pkt_type = fields[0]
              if not (0x01 <= pkt_type <= 0x06): return
              meta = in_meta if pmt.is_dict(in_meta) else pmt.make_dict()
              for k, v in [
                  ("pkt_type",     pmt.intern(PKT_STR.get(pkt_type, "UNKNOWN"))),
                  ("pkt_type_raw", pmt.from_uint64(pkt_type)),
                  ("media_type",   pmt.intern(MEDIA_STR.get(fields[1], "unknown"))),
                  ("src_addr",     pmt.from_uint64(fields[2])),
                  ("src_port",     pmt.from_uint64(fields[3])),
                  ("dst_addr",     pmt.from_uint64(fields[4])),
                  ("dst_port",     pmt.from_uint64(fields[5])),
                  ("seq_no",       pmt.from_uint64(fields[6])),
                  ("total_pkts",   pmt.from_uint64(fields[7])),
                  ("session_id",   pmt.from_uint64(fields[8])),
              ]:
                  meta = pmt.dict_add(meta, pmt.intern(k), v)
              payload  = raw[HDR_SIZE:]
              out_data = pmt.init_u8vector(len(payload), list(payload))
              self.message_port_pub(pmt.intern("pdus"), pmt.cons(meta, out_data))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 1: RX Header Parser'
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Fast Burst Packet Deframer RX (with Hamming FEC)
      - Vectorized NumPy sliding-window sync detection (fast C execution, minimal GIL load)
      - Positive correlation search only (180-deg phase ambiguity resolved upstream by diff decoder)
      - 1-bit false sync backtracking (prevents dropped frames on noise triggers)
      - fec = 0 / 15 / 31 and interleave must match the TX framer
      - Hamming decode: header section first (gives the length), then payload+CRC section
      - Full CRC32 verification over header + payload (after FEC correction)
      - Destination address filtering: drops frames where dest_id != peer_id
      - Message deduplication: displays payload once per msg_id, then logs burst statistics
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      HDR_BYTES = 6  # len (2B) + dest_id (1B) + msg_id (1B) + rep (1B) + n_reps (1B)


      def hamming_tables(n):
          """Standard positional Hamming layout: parity bits at positions 1, 2, 4, 8, (16)."""
          m = {15: 4, 31: 5}[n]
          pos = np.arange(1, n + 1)
          is_parity = (pos & (pos - 1)) == 0
          data_idx = np.flatnonzero(~is_parity)
          H = ((pos[None, :] >> np.arange(m)[:, None]) & 1).astype(np.int32)   # m x n, column j = bin(j)
          weights = (1 << np.arange(m)).astype(np.int32)
          return data_idx, H, weights


      def hamming_decode_bits(coded, n, nblk, interleave):
          """coded: nblk*n bits. Returns (data bits nblk*k, number of corrected bits)."""
          data_idx, H, weights = hamming_tables(n)
          c = np.asarray(coded, dtype=np.int32)
          cw = c.reshape(n, nblk).T.copy() if interleave else c.reshape(nblk, n).copy()
          S = ((cw @ H.T) & 1) @ weights          # syndrome = error position (1..n), 0 = no error
          bad = np.flatnonzero(S)
          cw[bad, S[bad] - 1] ^= 1                # flip bit at position S
          return cw[:, data_idx].reshape(-1).astype(np.uint8), int(bad.size)


      class PacketDeframerRX(gr.sync_block):
          def __init__(self, peer_id=1, max_bit_errors=2, max_payload_len=1024, bit_rate=375000,
                       fec=15, interleave=True):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX (Fast Burst, Hamming)",
                  in_sig=[np.uint8],
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.bit_rate = float(bit_rate)
              self.fec = int(fec)
              self.interleave = bool(interleave)
              if self.fec not in (0, 15, 31):
                  raise ValueError("fec must be 0, 15 or 31")

              # Bipolar template (+1 / -1) for correlation
              self._sync = np.unpackbits(np.frombuffer(SYNC_WORD, np.uint8)).astype(np.int16) * 2 - 1
              self._buf = np.zeros(0, dtype=np.uint8)

              self.n_sync = 0
              self.n_ok = 0
              self.n_crc_fail = 0
              self.n_bad_len = 0
              self.n_fec_corrected = 0      # total bits corrected by Hamming in CRC-valid frames

              self._bits_total = 0
              self._bits_at_last_ok = 0
              self._cur_id = None
              self._cur_reps = set()
              self._cur_nreps = 0
              self._cur_corr = 0

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("text_out"))

          # ---------- section sizes (in channel bits) ----------
          def _coded_len(self, n_bytes):
              if self.fec == 0:
                  return n_bytes * 8, 0
              nblk = -(-(n_bytes * 8) // {15: 11, 31: 26}[self.fec])
              return nblk * self.fec, nblk

          def _decode_section(self, coded, n_bytes, nblk):
              if self.fec == 0:
                  return np.packbits(coded).tobytes(), 0
              bits, corr = hamming_decode_bits(coded, self.fec, nblk, self.interleave)
              return np.packbits(bits[:n_bytes * 8]).tobytes(), corr

          # ---------- statistics / delivery ----------
          def _flush_summary(self):
              if self._cur_id is not None:
                  got, n = len(self._cur_reps), self._cur_nreps
                  loss = 100.0 * (n - got) / max(n, 1)
                  fec_txt = f", FEC corrected {self._cur_corr} bits" if self.fec else ""
                  print(f"[RX] msg #{self._cur_id}: {got}/{n} bursts OK (Loss: {loss:.0f}%){fec_txt}", flush=True)
              self._cur_id = None
              self._cur_reps = set()
              self._cur_corr = 0

          def _deliver(self, header, payload, corrected):
              dest_id, msg_id, rep, n_reps = header[2], header[3], header[4], header[5]
              if msg_id != self._cur_id:
                  self._flush_summary()
                  self._cur_id, self._cur_nreps = msg_id, n_reps
                  text = payload.decode("utf-8", errors="replace")
                  print("\n" + "=" * 40, flush=True)
                  print(f"[RX RECEIVED] #{msg_id}: {text}", flush=True)
                  print("=" * 40 + "\n", flush=True)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dest_id))
                  meta = pmt.dict_add(meta, pmt.intern("msg_id"), pmt.from_long(msg_id))
                  meta = pmt.dict_add(meta, pmt.intern("n_reps"), pmt.from_long(n_reps))
                  meta = pmt.dict_add(meta, pmt.intern("fec_corrected"), pmt.from_long(corrected))
                  vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
                  self.message_port_pub(pmt.intern("text_out"), pmt.intern(text))

              if rep not in self._cur_reps:
                  self._cur_corr += corrected
              self._cur_reps.add(rep)
              self._bits_at_last_ok = self._bits_total

          # ---------- main loop ----------
          def work(self, input_items, output_items):
              bits = input_items[0] & 1
              self._bits_total += len(bits)
              self._buf = np.concatenate((self._buf, bits)) if len(self._buf) else bits.copy()

              # Flush transmission stats once channel has been quiet for > 0.5s of air time
              if self._cur_id is not None and self._bits_total - self._bits_at_last_ok > 0.5 * self.bit_rate:
                  self._flush_summary()

              thr = 32 - 2 * self.max_bit_errors
              hdr_coded, hdr_blk = self._coded_len(HDR_BYTES)
              hdr_bits = 32 + hdr_coded

              while True:
                  buf = self._buf
                  if len(buf) < hdr_bits:
                      return len(bits)

                  # Fast matrix dot product over 32-bit window (only positive peaks)
                  pm = buf.astype(np.int16) * 2 - 1
                  corr = np.lib.stride_tricks.sliding_window_view(pm, 32) @ self._sync
                  cand = np.flatnonzero(corr >= thr)

                  if cand.size == 0:
                      self._buf = buf[-31:].copy()  # Preserve trailing bits that might begin a sync word
                      return len(bits)

                  i = int(cand[0])

                  if len(buf) < i + hdr_bits:
                      self._buf = buf[i:].copy()  # Await complete header bits
                      return len(bits)

                  header, hdr_corr = self._decode_section(buf[i + 32 : i + hdr_bits], HDR_BYTES, hdr_blk)
                  length = int.from_bytes(header[:2], "big")

                  if length == 0 or length > self.max_payload_len:
                      self.n_bad_len += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync
                      continue

                  body_coded, body_blk = self._coded_len(length + 4)
                  end = i + hdr_bits + body_coded
                  if len(buf) < end:
                      self._buf = buf[i:].copy()  # Await complete frame body bits
                      return len(bits)

                  body, body_corr = self._decode_section(buf[i + hdr_bits : end], length + 4, body_blk)
                  payload, rx_crc = body[:length], body[length:]
                  self.n_sync += 1

                  if zlib.crc32(header + payload) == int.from_bytes(rx_crc, "big"):
                      corrected = hdr_corr + body_corr
                      self.n_fec_corrected += corrected
                      dest_id = header[2]
                      if dest_id == self.peer_id:
                          self.n_ok += 1
                          self._deliver(header, payload, corrected)
                      # Frame addressed to another peer: discard silently
                      self._buf = buf[end:].copy()  # Advance past valid frame
                  else:
                      self.n_crc_fail += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync

              return len(bits)
    bit_rate: '375000'
    fec: FEC
    interleave: 'True'
    max_bit_errors: '1'
    max_payload_len: max_payload_len
    peer_id: (1-MY_ID)
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Burst Packet Framer TX (Hamming FEC + equalizer training word)
      - Outputs packed byte PDUs directly to pdu_pdu_to_tagged_stream
      - Frame layout:
          [preamble] [train word: F8 DD 42 58] [sync: 1A CF FC 1D] [coded section(s)] [postamble]
        Before coding the sections are:  header = [len:2B][dest_id:1B][msg_id:1B][rep:1B][n_reps:1B]
                                         body   = [payload][CRC32 over header+payload: 4B]
      - fec = 0  : header + body sent uncoded (identical to the non-FEC framer)
        fec = 15 : Hamming(15,11)    fec = 31 : Hamming(31,26)
        Preamble, train word and sync word are never coded (the correlator / deframer look for them as raw bits).
        Header and body are two separate coded sections (the receiver decodes the header first to learn the length);
        the coded bits are bit-for-bit what the previous FEC framer produced, so a deframer written for that
        format still decodes them. Anything after the body is ignored by the receiver.
      - interleave = True: each section's codewords are sent column by column (burst-error protection)
      - The train word is known to the RX: the correlator finds it, tags it, and the equalizer trains on it.
        It must match TRAIN_BITS in the flowgraph.
      - Postamble: pads the frame to a whole number of Pluto sink buffers (buffer_size is in SAMPLES, so one
        buffer = buffer_size / samples_per_byte bytes) and is never shorter than one buffer. The TX pulse-shaping
        filter holds back ~86 samples and the sink holds back the last partial buffer; both fall inside the
        postamble, so no frame bits are lost or delayed.
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      # 31-bit m-sequence + 1 pad bit. MUST match TRAIN_BITS in the flowgraph (RX side).
      TRAIN_WORD = bytes([0xF8, 0xDD, 0x42, 0x58])


      def hamming_tables(n):
          """Standard positional Hamming layout: parity bits at positions 1, 2, 4, 8, (16)."""
          m = {15: 4, 31: 5}[n]
          pos = np.arange(1, n + 1)
          is_parity = (pos & (pos - 1)) == 0
          data_idx = np.flatnonzero(~is_parity)          # 0-based indices of data positions
          par_idx = np.flatnonzero(is_parity)            # 0-based indices of 1, 2, 4, 8, (16)
          P = ((pos[data_idx, None] >> np.arange(m)) & 1).astype(np.int32)   # k x m
          return data_idx, par_idx, P


      def hamming_encode_bits(bits, n, interleave):
          """bits: 0/1 array. Pads to a multiple of k, returns the coded bit array."""
          data_idx, par_idx, P = hamming_tables(n)
          k = len(data_idx)
          nblk = -(-len(bits) // k)
          d = np.zeros(nblk * k, dtype=np.int32)
          d[:len(bits)] = bits
          d = d.reshape(nblk, k)
          cw = np.zeros((nblk, n), dtype=np.uint8)
          cw[:, data_idx] = d
          cw[:, par_idx] = (d @ P) & 1
          return (cw.T if interleave else cw).reshape(-1)


      class PacketFramerTX(gr.basic_block):
          def __init__(self, peer_id=1, preamble_len=64, repeat_count=1, max_payload_len=1024,
                       preamble_byte=0xFF, buffer_size=2048, postamble_byte=0xFF, train_enable=1,
                       fec=15, interleave=1, samples_per_byte=32):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst, FEC)",
                  in_sig=None,
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.buffer_size = int(buffer_size)              # Pluto sink buffer, in SAMPLES
              self.postamble_byte = int(postamble_byte) & 0xFF
              self.train_enable = int(train_enable)
              self.fec = int(fec)
              self.interleave = bool(int(interleave))
              self.samples_per_byte = max(1, int(samples_per_byte))   # 8 bits * samples/symbol (BPSK)
              if self.fec not in (0, 15, 31):
                  raise ValueError("fec must be 0, 15 or 31")
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def _encode_section(self, data):
              bits = np.unpackbits(np.frombuffer(data, dtype=np.uint8))
              return hamming_encode_bits(bits, self.fec, self.interleave)

          def _coded_body(self, header, payload):
              """Everything after the sync word: header + payload + CRC, coded if fec != 0."""
              crc = zlib.crc32(header + payload).to_bytes(4, "big")
              if self.fec == 0:
                  return header + payload + crc
              coded = np.concatenate((self._encode_section(header),
                                      self._encode_section(payload + crc)))
              return np.packbits(coded).tobytes()               # pads the last byte with 0s

          def _postamble_len(self, raw_len):
              """Bytes of postamble: at least one sink buffer, and total a whole number of buffers."""
              if self.buffer_size <= 0:
                  return 0
              unit = max(1, -(-self.buffer_size // self.samples_per_byte))    # bytes per sink buffer
              need = raw_len + unit                                           # leave one full buffer of postamble
              return (-(-need // unit)) * unit - raw_len

          def build_frame(self, header, payload):
              preamble = bytes([self.preamble_byte]) * self.preamble_len
              train = TRAIN_WORD if self.train_enable else b""
              raw = preamble + train + SYNC_WORD + self._coded_body(header, payload)
              return raw + bytes([self.postamble_byte]) * self._postamble_len(len(raw))

          def handle_msg(self, msg):
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return

              if not payload:
                  return

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[: self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              fec_txt = "no FEC" if self.fec == 0 else f"Hamming({self.fec},{self.fec - (4 if self.fec == 15 else 5)})"
              print(
                  f"[TX] msg #{msg_id} (to peer {self.peer_id}): '{payload.decode('utf-8', 'replace')}' "
                  f"({n_reps} bursts queued, {fec_txt})",
                  flush=True,
              )

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([self.peer_id, msg_id, rep, n_reps])
                  frame = self.build_frame(header, payload)

                  # Build metadata dictionary with tx_sob and tx_eob tags
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("tx_sob"), pmt.PMT_T)
                  meta = pmt.dict_add(meta, pmt.intern("tx_eob"), pmt.PMT_T)

                  # Explicit offset tags for downstream PDU-to-Tagged-Stream conversion
                  sob_tag = pmt.make_tuple(pmt.from_long(0), pmt.intern("tx_sob"), pmt.PMT_T)
                  eob_tag = pmt.make_tuple(pmt.from_long(len(frame) - 1), pmt.intern("tx_eob"), pmt.PMT_T)
                  extra_tags = pmt.list2(sob_tag, eob_tag)
                  meta = pmt.dict_add(meta, pmt.intern("extra_tags"), extra_tags)

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
    buffer_size: BUFFER_SIZE
    fec: FEC
    interleave: 'True'
    max_payload_len: max_payload_len
    peer_id: MY_ID
    postamble_byte: '0xFF'
    preamble_byte: '0xFF'
    preamble_len: '128'
    repeat_count: '1'
    samples_per_byte: 8*sps
    train_enable: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      # SR-ARQ FSM Core - patched: fixes A-E from INTEGRATION_NOTES.md (control timer slot,
      # post-session re-ACK, RX inactivity timeout, DATA retry cap, tx_done/tx_failed/tx_busy events)
      import os, struct, threading
      import pmt
      from gnuradio import gr

      PKT_SYN=0x01; PKT_SYN_ACK=0x02; PKT_DATA=0x03
      PKT_ACK=0x04; PKT_FIN=0x05; PKT_FIN_ACK=0x06
      MEDIA_CODE = {"text":0x01, "image":0x02, "audio":0x03}
      MEDIA_STR  = {0x01:"text", 0x02:"image", 0x03:"audio"}
      PKT_CODE   = {"SYN":PKT_SYN, "SYN_ACK":PKT_SYN_ACK, "DATA":PKT_DATA,
                    "ACK":PKT_ACK, "FIN":PKT_FIN, "FIN_ACK":PKT_FIN_ACK}
      PKT_STR    = {v:k for k,v in PKT_CODE.items()}
      IDLE="IDLE"; SYN_SENT="SYN_SENT"; SYN_RCVD="SYN_RCVD"
      TX_ACTIVE="TX_ACTIVE"; RX_ACTIVE="RX_ACTIVE"; FIN_SENT="FIN_SENT"


      class blk(gr.sync_block):
          """
          Block 2: SR-ARQ FSM Core
          Env vars: TL_M, TL_RTO_MS, TL_ROLE, TL_MTU, TL_LOCAL_ADDR,
                    TL_LOCAL_PORT, TL_MAX_RETRIES
          """

          def __init__(self,
                       m=int(os.environ.get('TL_M', '4')),
                       rto_ms=int(os.environ.get('TL_RTO_MS', '500')),
                       node_role=os.environ.get('TL_ROLE', 'initiator'),
                       mtu_bytes=int(os.environ.get('TL_MTU', '200')),
                       local_addr=int(os.environ.get('TL_LOCAL_ADDR', '0')),
                       local_port=int(os.environ.get('TL_LOCAL_PORT', '0')),
                       max_retries=int(os.environ.get('TL_MAX_RETRIES', '10'))):
              gr.sync_block.__init__(self, name="SR-ARQ FSM Core",
                                     in_sig=None, out_sig=None)
              assert node_role in ("initiator", "responder"), "TL_ROLE must be initiator or responder"
              assert 1 <= m <= 8,   "TL_M must be 1..8"
              assert mtu_bytes > 0, "TL_MTU must be > 0"
              self.m           = m
              self.seq_space   = 1 << m
              self.win_size    = 1 << (m - 1)
              self.rto_s       = rto_ms / 1000.0
              self.role        = node_role
              self.mtu         = mtu_bytes
              self.local_addr  = local_addr & 0xFF
              self.local_port  = local_port & 0xFF
              self.max_retries = max_retries
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("app_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("app_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu_in)
              self.set_msg_handler(pmt.intern("app_in"), self.handle_app_in)
              self._lock   = threading.Lock()
              self._timers = [None] * (self.seq_space + 1)
              self.last_done_sid = None
              self._reset_state()

          def _reset_state(self):
              self._cancel_all_timers()
              self.state = IDLE; self.session_id = 0
              self.dst_addr = 0; self.dst_port = 0
              self.ctrl_retries = 0; self.media_code = 0x00
              self.all_tx_pkts  = []
              self.tx_buf   = [None]  * self.seq_space
              self.acked    = [False] * self.seq_space
              self.data_retries = [0] * self.seq_space
              self.send_base = 0; self.next_seq_abs = 0; self.total_tx = 0
              self.rx_buf         = [None]  * self.seq_space
              self.received       = [False] * self.seq_space
              self.rcv_base = 0; self.total_rx = 0
              self.pkts_delivered = 0; self.reassembled = bytearray()

          def _start_timer(self, slot, timeout=None):
              self._cancel_timer(slot)
              t = threading.Timer(timeout or self.rto_s, self._on_timeout, args=[slot])
              t.daemon = True; self._timers[slot] = t; t.start()

          def _cancel_timer(self, slot):
              if self._timers[slot]:
                  self._timers[slot].cancel(); self._timers[slot] = None

          def _cancel_all_timers(self):
              if not hasattr(self, "_timers"): return
              for i in range(len(self._timers)): self._cancel_timer(i)

          def _on_timeout(self, slot):
              ctrl = self.seq_space
              with self._lock:
                  if slot == ctrl:
                      if self.state == SYN_SENT:
                          self.ctrl_retries += 1
                          if self.ctrl_retries > self.max_retries:
                              gr.log.error("FSM: SYN retry limit exceeded")
                              self._notify("tx_failed"); self._reset_state(); return
                          gr.log.warn(f"FSM: SYN RTO retry {self.ctrl_retries}/{self.max_retries}")
                          self._emit_ctrl(PKT_SYN, total_pkts=self.total_tx, media=self.media_code)
                          self._start_timer(ctrl)
                      elif self.state == FIN_SENT:
                          self.ctrl_retries += 1
                          if self.ctrl_retries > self.max_retries:
                              gr.log.warn("FSM: FIN retry limit exceeded")
                              self._notify("tx_done"); self._reset_state(); return
                          gr.log.warn(f"FSM: FIN RTO retry {self.ctrl_retries}/{self.max_retries}")
                          self._emit_ctrl(PKT_FIN)
                          self._start_timer(ctrl)
                      elif self.state in (SYN_RCVD, RX_ACTIVE):
                          gr.log.warn("FSM: peer went silent - abandoning RX session")
                          self._reset_state()
                  else:
                      if self.state == TX_ACTIVE and not self.acked[slot] and self.tx_buf[slot] is not None:
                          self.data_retries[slot] += 1
                          if self.data_retries[slot] > self.max_retries:
                              gr.log.error(f"FSM: DATA retry limit exceeded slot={slot}")
                              self._notify("tx_failed"); self._reset_state(); return
                          gr.log.warn(f"FSM: DATA RTO slot={slot}")
                          self._emit_data(slot); self._start_timer(slot)

          def handle_app_in(self, msg):
              if not pmt.is_pair(msg): return
              d = pmt.cdr(msg)
              if not pmt.is_u8vector(d): return
              frame = bytes(pmt.u8vector_elements(d))
              if len(frame) < 8:
                  gr.log.error("FSM app_in: frame too short"); return
              dst_addr, dst_port, type_byte, _ = struct.unpack_from(">BBBB", frame, 0)
              declared_len = struct.unpack_from(">I", frame, 4)[0]
              if len(frame) != 8 + declared_len:
                  gr.log.error("FSM app_in: length mismatch"); return
              with self._lock:
                  if self.state != IDLE:
                      gr.log.warn("FSM app_in: session active - dropping")
                      self._notify("tx_busy"); return
                  self.dst_addr = dst_addr & 0xFF; self.dst_port = dst_port & 0xFF
                  self.media_code = type_byte & 0xFF
                  self._packetize(frame)
                  self.session_id   = int.from_bytes(os.urandom(8), "big")
                  self.state        = SYN_SENT; self.ctrl_retries = 0
                  self._emit_ctrl(PKT_SYN, total_pkts=self.total_tx, media=self.media_code)
                  self._start_timer(self.seq_space)

          def handle_pdu_in(self, msg):
              if not pmt.is_pair(msg): return
              meta = pmt.car(msg); data = pmt.cdr(msg)
              if not pmt.is_dict(meta): return
              if not pmt.dict_has_key(meta, pmt.intern("pkt_type")): return
              pkt_str  = pmt.symbol_to_string(
                  pmt.dict_ref(meta, pmt.intern("pkt_type"), pmt.intern("")))
              pkt_code = PKT_CODE.get(pkt_str, 0)
              sid      = pmt.to_uint64(
                  pmt.dict_ref(meta, pmt.intern("session_id"), pmt.from_uint64(0)))
              payload  = bytes(pmt.u8vector_elements(data)) if pmt.is_u8vector(data) else b""
              def gu(k, d=0):
                  return pmt.to_uint64(pmt.dict_ref(meta, pmt.intern(k), pmt.from_uint64(d)))
              def gs(k, d=""):
                  return pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern(k), pmt.intern(d)))
              with self._lock:
                  if self.state != IDLE and pkt_code != PKT_SYN:
                      if sid != self.session_id: return
                  hdr = {"pkt_type":pkt_code, "media_type":MEDIA_CODE.get(gs("media_type"), 0),
                         "src_addr":gu("src_addr"), "src_port":gu("src_port"),
                         "dst_addr":gu("dst_addr"), "dst_port":gu("dst_port"),
                         "seq_no":gu("seq_no"), "total_pkts":gu("total_pkts"),
                         "session_id":sid}
                  # A SYN with a NEW session ID while we are receiving means the sender gave up on
                  # the old session and started a new one: drop the old one and accept the new SYN.
                  if (pkt_code == PKT_SYN and self.state in (SYN_RCVD, RX_ACTIVE)
                          and sid != self.session_id):
                      gr.log.warn("FSM: new session from peer - abandoning previous RX session")
                      self._reset_state()
                  dispatch = {IDLE:self._fsm_idle, SYN_SENT:self._fsm_syn_sent,
                              SYN_RCVD:self._fsm_syn_rcvd, TX_ACTIVE:self._fsm_tx_active,
                              RX_ACTIVE:self._fsm_rx_active, FIN_SENT:self._fsm_fin_sent}
                  if self.state in dispatch:
                      dispatch[self.state](hdr, payload)
                  if self.state in (SYN_RCVD, RX_ACTIVE):
                      self._start_timer(self.seq_space, self.rto_s * (self.max_retries + 2))

          def _fsm_idle(self, hdr, payload):
              if hdr["session_id"] == self.last_done_sid and hdr["pkt_type"] in (PKT_DATA, PKT_FIN):
                  self.session_id = hdr["session_id"]
                  self.dst_addr = hdr["src_addr"]; self.dst_port = hdr["src_port"]
                  if hdr["pkt_type"] == PKT_DATA: self._emit_ctrl(PKT_ACK, seq_no=hdr["seq_no"])
                  else:                           self._emit_ctrl(PKT_FIN_ACK)
                  self.session_id = 0; self.dst_addr = 0; self.dst_port = 0
                  return
              if hdr["pkt_type"] != PKT_SYN: return
              dst = hdr["dst_addr"]
              if self.local_addr != 0 and dst != 0 and dst != self.local_addr: return
              if self.local_port != 0 and hdr["dst_port"] != 0 and hdr["dst_port"] != self.local_port: return
              self.dst_addr=hdr["src_addr"]; self.dst_port=hdr["src_port"]
              self.session_id=hdr["session_id"]; self.total_rx=hdr["total_pkts"]
              self.media_code=hdr["media_type"]
              self.rcv_base=0; self.pkts_delivered=0; self.reassembled=bytearray()
              self.rx_buf=[None]*self.seq_space; self.received=[False]*self.seq_space
              self.state=SYN_RCVD; self._emit_ctrl(PKT_SYN_ACK)

          def _fsm_syn_sent(self, hdr, payload):
              if hdr["pkt_type"] != PKT_SYN_ACK: return
              self._cancel_timer(self.seq_space)
              self.state=TX_ACTIVE; self.send_base=0; self.next_seq_abs=0
              for _ in range(min(self.win_size, self.total_tx)):
                  slot=self.next_seq_abs % self.seq_space
                  self.tx_buf[slot]=self.all_tx_pkts[self.next_seq_abs]; self.acked[slot]=False; self.data_retries[slot]=0
                  self._emit_data(slot); self._start_timer(slot); self.next_seq_abs+=1

          def _fsm_syn_rcvd(self, hdr, payload):
              if hdr["pkt_type"]==PKT_SYN: self._emit_ctrl(PKT_SYN_ACK); return
              if hdr["pkt_type"]==PKT_DATA: self.state=RX_ACTIVE; self._fsm_rx_active(hdr, payload)

          def _fsm_tx_active(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_ACK: return
              seq=hdr["seq_no"]
              if self.acked[seq]: return
              self.acked[seq]=True; self._cancel_timer(seq); self._advance_window()

          def _fsm_rx_active(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_DATA: return
              seq=hdr["seq_no"]
              in_win=any(seq==(self.rcv_base+i)%self.seq_space for i in range(self.win_size))
              self._emit_ctrl(PKT_ACK, seq_no=seq)
              if not in_win: return
              if not self.received[seq]: self.received[seq]=True; self.rx_buf[seq]=payload
              self._try_deliver()

          def _fsm_fin_sent(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_FIN_ACK: return
              self._cancel_timer(self.seq_space); self._notify("tx_done"); self._reset_state()

          def _advance_window(self):
              while self.send_base < self.total_tx and self.acked[self.send_base % self.seq_space]:
                  slot=self.send_base%self.seq_space
                  self.acked[slot]=False; self.tx_buf[slot]=None; self.send_base+=1
                  if self.next_seq_abs < self.total_tx:
                      ns=self.next_seq_abs%self.seq_space
                      self.tx_buf[ns]=self.all_tx_pkts[self.next_seq_abs]; self.acked[ns]=False; self.data_retries[ns]=0
                      self._emit_data(ns); self._start_timer(ns); self.next_seq_abs+=1
              if self.send_base >= self.total_tx:
                  self.state=FIN_SENT; self.ctrl_retries=0
                  self._emit_ctrl(PKT_FIN); self._start_timer(self.seq_space)

          def _try_deliver(self):
              while self.pkts_delivered < self.total_rx and self.received[self.rcv_base]:
                  self.reassembled.extend(self.rx_buf[self.rcv_base])
                  self.received[self.rcv_base]=False; self.rx_buf[self.rcv_base]=None
                  self.rcv_base=(self.rcv_base+1)%self.seq_space; self.pkts_delivered+=1
              if self.pkts_delivered == self.total_rx:
                  out=bytes(self.reassembled)
                  m=pmt.make_dict()
                  for k,v in [("payload_type",pmt.intern(MEDIA_STR.get(self.media_code,"unknown"))),
                              ("session_id",pmt.from_uint64(self.session_id)),
                              ("src_addr",pmt.from_uint64(self.dst_addr)),
                              ("src_port",pmt.from_uint64(self.dst_port)),
                              ("dst_addr",pmt.from_uint64(self.local_addr)),
                              ("dst_port",pmt.from_uint64(self.local_port))]:
                      m=pmt.dict_add(m, pmt.intern(k), v)
                  self.message_port_pub(pmt.intern("app_out"),
                      pmt.cons(m, pmt.init_u8vector(len(out), list(out))))
                  self._emit_ctrl(PKT_FIN_ACK)
                  self.last_done_sid = self.session_id
                  self._reset_state()

          def _notify(self, event):
              m = pmt.dict_add(pmt.make_dict(), pmt.intern("event"), pmt.intern(event))
              m = pmt.dict_add(m, pmt.intern("session_id"), pmt.from_uint64(self.session_id))
              # 1-byte dummy payload: an EMPTY u8vector crashes the C++ ZMQ sink's serializer
              # on distros built with _GLIBCXX_ASSERTIONS (Fedora): "Assertion '__n < this->size()'"
              self.message_port_pub(pmt.intern("app_out"), pmt.cons(m, pmt.init_u8vector(1, [0])))

          def _packetize(self, raw):
              self.all_tx_pkts=[raw[i:i+self.mtu] for i in range(0,len(raw),self.mtu)]
              self.tx_buf=[None]*self.seq_space; self.acked=[False]*self.seq_space
              self.total_tx=len(self.all_tx_pkts); self.send_base=0; self.next_seq_abs=0

          def _make_meta(self, pkt_code, seq_no=0, total_pkts=0, media=0):
              m=pmt.make_dict()
              for k,v in [("pkt_type",pmt.intern(PKT_STR.get(pkt_code,"UNKNOWN"))),
                          ("pkt_type_raw",pmt.from_uint64(pkt_code)),
                          ("seq_no",pmt.from_uint64(seq_no)),
                          ("total_pkts",pmt.from_uint64(total_pkts)),
                          ("media_type",pmt.intern(MEDIA_STR.get(media,"unknown"))),
                          ("media_raw",pmt.from_uint64(media)),
                          ("src_addr",pmt.from_uint64(self.local_addr)),
                          ("src_port",pmt.from_uint64(self.local_port)),
                          ("dst_addr",pmt.from_uint64(self.dst_addr)),
                          ("dst_port",pmt.from_uint64(self.dst_port)),
                          ("session_id",pmt.from_uint64(self.session_id))]:
                  m=pmt.dict_add(m, pmt.intern(k), v)
              return m

          def _emit_ctrl(self, pkt_code, seq_no=0, total_pkts=0, media=None):
              if media is None: media=self.media_code
              meta=self._make_meta(pkt_code, seq_no=seq_no, total_pkts=total_pkts, media=media)
              self.message_port_pub(pmt.intern("pdu_out"),
                  pmt.cons(meta, pmt.init_u8vector(0, [])))

          def _emit_data(self, slot):
              chunk=self.tx_buf[slot]
              if chunk is None: return
              meta=self._make_meta(PKT_DATA, seq_no=slot, total_pkts=self.total_tx, media=self.media_code)
              self.message_port_pub(pmt.intern("pdu_out"),
                  pmt.cons(meta, pmt.init_u8vector(len(chunk), list(chunk))))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 2: SR-ARQ FSM Core'
    local_addr: tl_local_addr
    local_port: tl_local_port
    m: tl_m
    max_retries: tl_max_retries
    mtu_bytes: tl_mtu
    node_role: tl_role
    rto_ms: tl_rto_ms
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import struct, pmt
      from gnuradio import gr

      HDR_FMT    = ">BBBBBBHHQ"
      PKT_CODE   = {"SYN":0x01, "SYN_ACK":0x02, "DATA":0x03,
                    "ACK":0x04, "FIN":0x05, "FIN_ACK":0x06}
      MEDIA_CODE = {"text":0x01, "image":0x02, "audio":0x03}


      class blk(gr.sync_block):
          """Block 3: TX Header Serializer -- stateless 18-byte binary header serializer."""

          def __init__(self):
              gr.sync_block.__init__(self, name='TX Header Serializer',
                                     in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg): return
              meta = pmt.car(msg); data = pmt.cdr(msg)
              if not pmt.is_dict(meta): return
              def gu(k, d=0):
                  return pmt.to_uint64(pmt.dict_ref(meta, pmt.intern(k), pmt.from_uint64(d)))
              def gs(k, d=""):
                  return pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern(k), pmt.intern(d)))
              hdr = struct.pack(HDR_FMT,
                  PKT_CODE.get(gs("pkt_type"), 0),
                  MEDIA_CODE.get(gs("media_type"), 0),
                  gu("src_addr") & 0xFF, gu("src_port") & 0xFF,
                  gu("dst_addr") & 0xFF, gu("dst_port") & 0xFF,
                  gu("seq_no")    & 0xFFFF,
                  gu("total_pkts") & 0xFFFF,
                  gu("session_id"))
              payload  = bytes(pmt.u8vector_elements(data)) if pmt.is_u8vector(data) else b""
              frame    = hdr + payload
              out_data = pmt.init_u8vector(len(frame), list(frame))
              self.message_port_pub(pmt.intern("pdus"), pmt.cons(meta, out_data))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 3: TX Header Serializer'
  states: {}
- name: epy_block_corr
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Training-word correlator (drop-in for digital_corr_est_cc)
      - Input : complex stream at 2 samples/symbol (symbol sync output)
      - Output: the same stream delayed by a fixed EVEN number of samples (so tags can be placed in the past
        without shifting the symbol / midpoint sample phase)
      - Slides the reference (TRAIN_REF) over the stream and computes the NORMALIZED correlation
            rho = |sum(conj(ref) * x)|^2 / (E_ref * E_window)      (0..1, independent of signal amplitude)
        Where rho has a local maximum above thr it adds a 'corr_est' tag (and 'corr_start') on the
        first training symbol, shifted by mark_delay samples. Random data gives rho ~ 0.1-0.25; a real
        training word gives ~0.8-1.0, so thr ~ 0.6-0.7 is a good start. The tag value is rho.
      - Pure numpy, bounds-checked: no use of GNU Radio's corr_est_cc.
      """
      import numpy as np
      import pmt
      from gnuradio import gr


      class TrainCorr(gr.sync_block):
          def __init__(self, ref=None, thr=0.7, mark_delay=0, verbose=1):
              gr.sync_block.__init__(
                  self,
                  name="Training-word Correlator",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
              if ref is None:
                  ref = [1.0]
              self._ref = np.asarray(ref, dtype=np.complex64)
              self._L = len(self._ref)
              self._E = float(np.sum(np.abs(self._ref) ** 2))
              self.thr = float(thr)
              self.mark_delay = max(0, int(mark_delay))
              self.verbose = int(verbose)
              # Output delay: >= L + 3 so every peak is examined exactly once, and a MULTIPLE OF 2 (samples per
              # symbol) so the symbol-timed samples stay on even stream indices -- the linear equalizer takes
              # the first sample of every 2-sample block, so an odd delay would make it sample the midpoints.
              self._D = self._L + 8
              self._D += self._D % 2
              self.set_history(self._D + 1)
              self._next_p = 0               # first absolute input index not yet examined
              self._last_p = -10**12         # last tagged absolute input index
              self._seen = 0                 # samples since last status line
              self._best = 0.0               # strongest normalized correlation since last status line

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out[:] = x[:n_out]             # in[i] <-> absolute input index a-D+i  ==  output index a+i

              a = self.nitems_written(0)
              base = a - self._D             # absolute input index of x[0]
              if len(x) < self._L + 5:
                  return n_out
              c = np.correlate(x, self._ref, "valid")                  # window starting at x[n]
              w = np.convolve(np.abs(x).astype(np.float64) ** 2, np.ones(self._L), "valid")
              m = (np.abs(c).astype(np.float64) ** 2) / (self._E * w + 1e-12)    # normalized, 0..1
              self._best = max(self._best, float(m.max()))
              self._seen += n_out

              n0 = max(self._next_p - base, 2, -base)       # first window start to examine (p >= 0)
              n1 = len(m) - 3                               # last start with 2 neighbours on the right
              if n1 >= n0:
                  seg = m[n0 - 2 : n1 + 3]
                  mid = seg[2:-2]
                  thr_abs = self.thr
                  cond = (
                      (mid > thr_abs)
                      & (mid > seg[0:-4]) & (mid > seg[1:-3])
                      & (mid >= seg[3:-1]) & (mid >= seg[4:])
                  )
                  for j in np.flatnonzero(cond):
                      p = base + n0 + int(j)
                      if p - self._last_p < self._L:
                          continue
                      self._last_p = p
                      ratio = float(mid[j])
                      off = int(p + self._D + self.mark_delay)    # output index; always >= a
                      val = pmt.from_double(ratio)
                      self.add_item_tag(0, off, pmt.intern("corr_start"), val)
                      self.add_item_tag(0, off, pmt.intern("corr_est"), val)
                      self._best = 0.0
                      self._seen = 0
                      if self.verbose:
                          print(f"[CORR] train word found: correlation = {ratio:.2f} (thr {self.thr:.2f})", flush=True)
                  self._next_p = base + n1 + 1

              if self.verbose and self._seen > 400000:
                  if self._best > 0.35:
                      print(f"[CORR] no tag; strongest correlation in last window = {self._best:.2f} (thr {self.thr:.2f})", flush=True)
                  self._best = 0.0
                  self._seen = 0
              return n_out
    comment: Python replacement for digital_corr_est_cc (avoids its out-of-range read).
    mark_delay: train_delay
    ref: TRAIN_REF
    thr: corr_thr
    verbose: '1'
  states: {}
- name: epy_noise
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Noise-floor tracker -> automatic squelch threshold
      - Sink block: connect it to the SDR source output (BEFORE any squelch/AGC).
      - Splits the stream into short slices (default ~1 ms), keeps the mean power of each slice for the
        last `window_s` seconds, and takes a low percentile of them as the noise floor (bursts only occupy
        the top of the distribution, so they are ignored as long as the channel is idle > `percentile` % of the time).
      - level() returns the squelch threshold in dB:  noise floor (dB) + margin_db, clamped to
        [thr_min, thr_max]. The estimate falls immediately but rises at most `rise_db_s` dB per second, so a
        long burst or a back-to-back transmission cannot drag the threshold up and close the squelch.
      - Use with a "Function Probe" variable named power_threshold:  block id = this block, function = level,
        poll rate ~ 5 Hz. The Pluto/squelch power unit is the same: dB of mean |x|^2.
      """
      import threading
      import time
      from collections import deque

      import numpy as np
      from gnuradio import gr


      class NoiseFloor(gr.sync_block):
          def __init__(self, samp_rate=1.5e6, margin_db=6.0, window_s=1.0, percentile=10.0,
                       rise_db_s=1.0, thr_min=-100.0, thr_max=-20.0, init_db=-40.0, verbose=1):
              gr.sync_block.__init__(self, name="Noise Floor Tracker", in_sig=[np.complex64], out_sig=None)
              self.samp_rate = float(samp_rate)
              self.margin_db = float(margin_db)
              self.window_s = float(window_s)
              self.percentile = float(percentile)
              self.rise_db_s = float(rise_db_s)
              self.thr_min = float(thr_min)
              self.thr_max = float(thr_max)
              self.init_db = float(init_db)
              self.verbose = int(verbose)

              self._slice = max(64, int(self.samp_rate * 1e-3))            # ~1 ms
              n_slices = max(16, int(self.window_s * self.samp_rate / self._slice))
              self._ring = deque(maxlen=n_slices)
              self._min_slices = max(8, n_slices // 4)                       # wait for 1/4 window before trusting
              self._carry = np.zeros(0, np.float32)
              self._lock = threading.Lock()
              self._est_db = None
              self._t_last = None
              self._out = self.init_db
              self._printed = None

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              if n == 0:
                  return 0
              p = x.real.astype(np.float32) ** 2 + x.imag.astype(np.float32) ** 2
              if self._carry.size:
                  p = np.concatenate((self._carry, p))
              k = len(p) // self._slice
              if k:
                  means = p[: k * self._slice].reshape(k, self._slice).mean(axis=1, dtype=np.float64)
                  with self._lock:
                      self._ring.extend(means)
              self._carry = p[k * self._slice:]
              return n

          def noise_db(self):
              return self._est_db

          def level(self):
              """Called by the Function Probe variable: returns the squelch threshold in dB."""
              with self._lock:
                  arr = np.fromiter(self._ring, dtype=np.float64, count=len(self._ring))
              if arr.size < self._min_slices:
                  return self._out
              raw_db = 10.0 * np.log10(max(float(np.percentile(arr, self.percentile)), 1e-20))
              now = time.monotonic()
              if self._est_db is None:
                  self._est_db = raw_db
              else:
                  dt = max(0.0, now - self._t_last)
                  if raw_db <= self._est_db:
                      self._est_db = raw_db
                  else:
                      self._est_db = min(raw_db, self._est_db + self.rise_db_s * dt)
              self._t_last = now
              self._out = float(min(self.thr_max, max(self.thr_min, self._est_db + self.margin_db)))
              if self.verbose and (self._printed is None or abs(self._out - self._printed) >= 1.0):
                  print(f"[SQL] noise floor {self._est_db:.1f} dB -> squelch threshold {self._out:.1f} dB", flush=True)
                  self._printed = self._out
              return self._out
    init_db: '-40.0'
    margin_db: margin_db
    percentile: '10.0'
    rise_db_s: '1.0'
    samp_rate: samp_rate
    thr_max: '-20.0'
    thr_min: '-100.0'
    verbose: '1'
    window_s: '1.0'
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: FILTER_BW
    buffer_size: BUFFER_SIZE
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: TX_FREQ
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: FILTER_BW
    bbdc: 'True'
    buffer_size: BUFFER_SIZE
    filter_source: '''Auto'''
    frequency: RX_FREQ
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: |-
      import os
      from gnuradio import zeromq
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'v3.3: train word (F8 DD 42 58) + python correlator + NLMS equalizer. Tune corr_thr (0.3-0.98) first.'
  states: {}
- name: note_1
  id: note
  parameters:
    note: To observe signal power
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    comment: Unicast filter
    invert: 'False'
    k: pmt.intern("dst_addr")
    v: pmt.from_uint64(tl_local_addr)
  states: {}
- name: pdu_pdu_filter_0_0
  id: pdu_pdu_filter
  parameters:
    comment: Broadcast filter
    invert: 'False'
    k: pmt.intern("dst_addr")
    v: pmt.from_uint64(0)
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0'
    ymin: '-55'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: '"FLL freq"'
    ymin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://127.0.0.1:" + str(tl_zmq_tx_port)'
    bind: 'True'
    comment: Binds and receives from folder_sync_daemon PUSH (port tl_zmq_tx_port)
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://127.0.0.1:" + str(tl_zmq_rx_port)'
    comment: Binds and sends reassembled data to folder_sync_daemon PULL (port tl_zmq_rx_port)
    timeout: '100'
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', blocks_copy_1_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_1, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_5_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', virtual_sink_5_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '1', qtgui_time_sink_x_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_corr, '0']
- [epy_block_0, pdus, pdu_pdu_filter_0, pdus]
- [epy_block_0, pdus, pdu_pdu_filter_0_0, pdus]
- [epy_block_0_0_0_0, pdu_out, epy_block_0, pdus]
- [epy_block_0_0_1, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_1, app_out, zeromq_push_msg_sink_0, in]
- [epy_block_1, pdu_out, epy_block_2, pdus]
- [epy_block_2, pdus, blocks_message_debug_1, print_pdu]
- [epy_block_2, pdus, epy_block_0_0_1, msg_in]
- [epy_block_corr, '0', blocks_tag_debug_corr, '0']
- [epy_block_corr, '0', digital_linear_equalizer_0, '0']
- [iio_pluto_source_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [iio_pluto_source_0, '0', epy_noise, '0']
- [pdu_pdu_filter_0, pdus, epy_block_1, pdu_in]
- [pdu_pdu_filter_0_0, pdus, epy_block_1, pdu_in]
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', blocks_copy_0_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print_pdu]
- [zeromq_pull_msg_source_0, out, epy_block_1, app_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
