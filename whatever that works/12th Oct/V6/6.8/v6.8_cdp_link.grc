options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: cdp_link_v68
    output_language: python
    title: CDP link v6.8 (on-air ARQ timers)
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: BUFFER_SIZE
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: CH_GAIN
  id: variable_qtgui_range
  parameters:
    comment: Pluto TX attenuation used for own bursts. While idle the CSMA block sets 89.75 dB (if 'Mute TX when idle').
    label: TX attenuation while sending (dB)
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: float(os.environ.get('CDP_TX_ATT', '20'))
  states: {}
- name: DEST_ID
  id: variable_qtgui_entry
  parameters:
    comment: 'Default destination for typed messages: 0..254 = that node, 255 = every node. Start value from env CDP_DEST. Type a new ID and press Enter / leave the box.'
    label: Dest ID (255 = all)
    type: int
    value: int(os.environ.get('CDP_DEST', '255'))
  states: {}
- name: FEC
  id: variable
  parameters:
    comment: |-
      0 = no FEC
      15 = Hamming(15,11)
      31 = Hamming(31,26)
    value: '31'
  states: {}
- name: FILTER_BW
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: FREQ
  id: variable
  parameters:
    comment: Single frequency (half duplex, CSMA). Both nodes TX and RX here.
    value: TX_FREQ_A
  states: {}
- name: MY_ID
  id: variable
  parameters:
    comment: This node's src ID, 0..254, different on every node. From env CDP_MY_ID (default 1).
    value: int(os.environ.get('CDP_MY_ID', '1'))
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: RC_PULSE
  id: variable
  parameters:
    value: np.sinc(RC_X)*np.cos(np.pi*alpha*RC_X)/(1-(2*alpha*RC_X)**2)
  states: {}
- name: RC_X
  id: variable
  parameters:
    value: np.arange(-8, 9)/2.0
  states: {}
- name: RX_AMP
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: RX_FREQ
  id: variable
  parameters:
    value: FREQ
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: SET_ARQ_ACK_DELAY
  id: variable
  parameters:
    comment: receiver ACKs at the latest after this, s. Env CDP_ARQ_ACK_DELAY, default 0.5.
    value: float(os.environ.get('CDP_ARQ_ACK_DELAY', '0.5'))
  states: {}
- name: SET_ARQ_ACK_EVERY
  id: variable
  parameters:
    comment: receiver ACKs at least every N segments. Env CDP_ARQ_ACK_EVERY, default 4.
    value: int(os.environ.get('CDP_ARQ_ACK_EVERY', '4'))
  states: {}
- name: SET_ARQ_INIT_RTO
  id: variable
  parameters:
    comment: ARQ first timeout, s. Env CDP_ARQ_INIT_RTO, default 1.0.
    value: float(os.environ.get('CDP_ARQ_INIT_RTO', '1.0'))
  states: {}
- name: SET_ARQ_MAX_RTO
  id: variable
  parameters:
    comment: ARQ longest timeout (after back-off), s. Env CDP_ARQ_MAX_RTO, default 4.0.
    value: float(os.environ.get('CDP_ARQ_MAX_RTO', '4.0'))
  states: {}
- name: SET_ARQ_MIN_RTO
  id: variable
  parameters:
    comment: ARQ shortest timeout, s. Env CDP_ARQ_MIN_RTO, default 0.5.
    value: float(os.environ.get('CDP_ARQ_MIN_RTO', '0.5'))
  states: {}
- name: SET_ARQ_MSS
  id: variable
  parameters:
    comment: ARQ data bytes per frame (max 2037). Env CDP_ARQ_MSS, default 1000.
    value: int(os.environ.get('CDP_ARQ_MSS', '1000'))
  states: {}
- name: SET_ARQ_RETRIES
  id: variable
  parameters:
    comment: transmissions per segment before FAIL. Env CDP_ARQ_RETRIES, default 8.
    value: int(os.environ.get('CDP_ARQ_RETRIES', '8'))
  states: {}
- name: SET_ARQ_WINDOW
  id: variable
  parameters:
    comment: ARQ segments in flight (1-32). Env CDP_ARQ_WINDOW, default 8.
    value: int(os.environ.get('CDP_ARQ_WINDOW', '8'))
  states: {}
- name: SET_CSMA_CWMAX
  id: variable
  parameters:
    comment: CSMA largest backoff window. Env CDP_CSMA_CWMAX, default 128.
    value: int(os.environ.get('CDP_CSMA_CWMAX', '128'))
  states: {}
- name: SET_CSMA_CWMIN
  id: variable
  parameters:
    comment: CSMA backoff window, slots. Env CDP_CSMA_CWMIN, default 8.
    value: int(os.environ.get('CDP_CSMA_CWMIN', '8'))
  states: {}
- name: SET_CSMA_DIFS
  id: variable
  parameters:
    comment: CSMA quiet time before counting slots, s. Env CDP_CSMA_DIFS, default 0.020.
    value: float(os.environ.get('CDP_CSMA_DIFS', '0.020'))
  states: {}
- name: SET_CSMA_GUARD
  id: variable
  parameters:
    comment: extra RX-off time after own burst, s. Env CDP_CSMA_GUARD, default 0.005.
    value: float(os.environ.get('CDP_CSMA_GUARD', '0.005'))
  states: {}
- name: SET_CSMA_SLOT
  id: variable
  parameters:
    comment: CSMA slot, s (> own echo max + write time). Env CDP_CSMA_SLOT, default 0.015.
    value: float(os.environ.get('CDP_CSMA_SLOT', '0.015'))
  states: {}
- name: SET_CSMA_TXDELAY
  id: variable
  parameters:
    comment: min. radio TX+RX delay for the RX-off window, s. Env CDP_CSMA_TXDELAY, default 0.012.
    value: float(os.environ.get('CDP_CSMA_TXDELAY', '0.012'))
  states: {}
- name: SET_DEBUG
  id: variable
  parameters:
    comment: deframer [RX dbg] lines (0 = off, saves CPU). Env CDP_DEBUG, default 1.
    value: int(os.environ.get('CDP_DEBUG', '1'))
  states: {}
- name: SET_LOG_DIR
  id: variable
  parameters:
    comment: telemetry / stack-dump folder. Env CDP_LOG_DIR, default ~/.cdp_link.
    value: os.environ.get('CDP_LOG_DIR', '~/.cdp_link')
  states: {}
- name: SET_TELEM_PORT
  id: variable
  parameters:
    comment: dashboard telemetry port. Env CDP_TELEM_PORT, default 5300.
    value: int(os.environ.get('CDP_TELEM_PORT', '5300'))
  states: {}
- name: TRAIN_BITS
  id: variable
  parameters:
    value: np.unpackbits(np.frombuffer(bytes([0xF8, 0xDD, 0x42, 0x58]), np.uint8))
  states: {}
- name: TRAIN_REF
  id: variable
  parameters:
    value: list(map(complex, RX_AMP*np.convolve(np.kron(TRAIN_SYMS, [1, 0]), RC_PULSE)[8:8+2*len(TRAIN_SYMS)-1]))
  states: {}
- name: TRAIN_SYMS
  id: variable
  parameters:
    value: list(map(complex, 1 - 2*np.bitwise_xor.accumulate(TRAIN_BITS).astype(int)))
  states: {}
- name: TX_FREQ
  id: variable
  parameters:
    value: FREQ
  states: {}
- name: TX_FREQ_A
  id: variable
  parameters:
    value: int(1250e6)
  states: {}
- name: TX_FREQ_B
  id: variable
  parameters:
    value: int(1270e6)
  states: {}
- name: TX_MUTE
  id: variable_qtgui_check_box
  parameters:
    comment: 1 = TX attenuation 89.75 dB whenever this node is not sending (CSMA block, via libiio).
    'false': '0'
    label: Mute TX when idle
    'true': '1'
    type: int
    value: int(os.environ.get('CDP_TX_MUTE', '1'))
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    step_size: '0.5'
    type: nlms
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: corr_thr
  id: variable_qtgui_range
  parameters:
    comment: Normalized correlation threshold (0..1). Random data ~0.1-0.25, real train word ~0.8-1.0.
    start: '0.3'
    step: '0.01'
    stop: '0.98'
    value: '0.7'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.06'
  states: {}
- name: cs_margin
  id: variable_qtgui_range
  parameters:
    label: CSMA sense margin (dB)
    start: '3'
    step: '0.5'
    stop: '15'
    value: float(os.environ.get('CDP_CS_MARGIN', '6'))
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: margin_db
  id: variable_qtgui_range
  parameters:
    label: Squelch margin over noise (dB)
    start: '2'
    step: '0.5'
    stop: '20'
    value: float(os.environ.get('CDP_SQ_MARGIN', '6'))
  states: {}
- name: max_payload_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: power_threshold
  id: variable_function_probe
  parameters:
    block_id: epy_noise
    comment: Automatic squelch threshold (dB) from the noise-floor tracker
    function_name: level
    poll_rate: '5'
    value: '-40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.020'
  states: {}
- name: train_delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '12'
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '5e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_corr
  id: blocks_tag_debug
  parameters:
    filter: '"corr_est"'
    name: corr_est
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '32'
    lengthtagname: '''packet_len'''
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: 'Bypassed. Enable (E) if [RX dbg] shows train words with broken sync words and raising this PC''s TX attenuation fixes it: own LO leakage at 0 Hz.'
    length: '128'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: 'False'
    alg: adpt_alg
    num_taps: '7'
    sps: '2'
    training_sequence: TRAIN_SYMS
    training_start_tag: '"corr_est"'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '0.05'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_arq
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: ARQ Transport (TCP-like reliable messages) + socket for an external daemon

      Wiring
        Packet Deframer RX pdu_out -> pdu_in        pdu_out -> Packet Framer TX msg_in        (mac_ctrl: optional -> CSMA ctrl)
        CSMA tx_start -> mac_in (v6.8): the CSMA reports when each frame really goes on air. The retransmission timer of
        a segment starts then, so time spent waiting in the CSMA queue / backoff is never mistaken for a loss and the
        RTO can be short. Without this connection the timer starts when the segment is handed to the radio (as v6.7);
        a segment the CSMA never reports (dropped from its queue) is treated as sent after mac_wait_s.
        Every frame carries metadata "arq_tag"; ACKs and retransmissions also "prio" (the CSMA queues them first).

      What it does
        The daemon hands over whole messages (any size up to max_msg_bytes) for one node ID. The block cuts them into
        segments of at most mss bytes, sends them with a sliding window (selective-repeat ARQ), retransmits what is not
        acknowledged, and the receiving block puts each message back together and hands it, complete and in order, to
        its own daemon. The sender's daemon is told when a message is confirmed (SENT) or given up (FAIL).
        Unicast only (dest 0..254). One sender session per block start: a restarted node is recognised and its peer
        resets its receive state, so sequence numbers never get mixed between runs.

      On air (inside the framer payload; the framer adds src_id / dest_id)
        DATA  C5 02 | session 4B | seq 2B | base 2B | flags 1B | data        (11-byte header; flags: 1 = first segment
                                                                               of a message, 2 = last, 4 = ACK now)
        ACK   C5 03 | session 4B | cum 2B | sack 4B                          (12 bytes)
          seq:  segment number (16 bit, per sender session and destination)
          base: the sender's lowest segment still in play; it will never send anything below it again, so the receiver
                gives up on segments below base it is still missing (abandoned) and uses the ones it already has
          cum:  next segment the receiver expects (all before it received); sack: bit i = segment cum+1+i received
        Each ACK costs a whole frame (channel access + airtime), so ACKs are few: the sender sets "ACK now" on the last
        segment of each burst it hands to the radio (window full or nothing more to send, and on retransmissions); the
        receiver ACKs on that flag, after ack_every segments, or at the latest ack_delay_s after a segment. A duplicate
        (the sender missed our ACK) also brings the ACK forward.
        Retransmission: per-segment timer with an adaptive RTO (srtt + 4 * rttvar, min_rto_s..max_rto_s, doubled on
        timeout), plus SACK-based early retransmission of holes. On a timeout only the OLDEST overdue segment is sent
        again (with ACK now): the ACK it brings back carries the full receive state, so the rest is resent early only
        if really missing (a lost ACK costs one duplicate, not a whole window). A congestion window (cwnd, at most window) is halved
        on a timeout and grows by one per ACK, so delay spikes on the shared channel don't trigger bursts of
        duplicates. After max_retries transmissions the message is reported FAIL and its segments are abandoned.

      Daemon socket: TCP server on bind_addr:port. Every frame both ways = 4-byte big-endian length + body.
        daemon -> block   SEND   01 | ref 4B | dest 1B | message bytes
        block -> daemon   HELLO  80 | src_id 1B | mss 2B | window 1B | max_msg 4B          (on connect)
                          RECV   81 | src 1B | message bytes                              (to every connected client)
                          SENT   82 | ref 4B | dest 1B                                     (to the client that sent it)
                          FAIL   83 | ref 4B | dest 1B | reason 1B   (1 no ACK after max_retries, 2 bad dest, 3 queue full,
                                                                        4 too large, 5 empty)
        RECV messages that arrive while no client is connected are kept (up to rx_keep_msgs) and handed to the next one.
      """
      import collections
      import os
      import random
      import selectors
      import socket
      import struct
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      def _cdp_register(name, blk):
          """Shared registry (one per flowgraph process) read by the Telemetry block."""
          import sys as _sys, types as _types
          reg = _sys.modules.get("cdp_registry")
          if reg is None:
              reg = _types.ModuleType("cdp_registry")
              reg.blocks = {}
              _sys.modules["cdp_registry"] = reg
          reg.blocks[name] = blk

      MAGIC = 0xC5
      P_DATA, P_ACK = 0x02, 0x03
      F_FIRST, F_LAST, F_ACKNOW = 0x01, 0x02, 0x04
      DATA_HDR = struct.Struct(">BBIHHB")
      ACK_PKT = struct.Struct(">BBIHI")
      C_SEND = 0x01
      E_HELLO, E_RECV, E_SENT, E_FAIL = 0x80, 0x81, 0x82, 0x83
      FAIL_RETRIES, FAIL_DEST, FAIL_QUEUE, FAIL_SIZE, FAIL_EMPTY = 1, 2, 3, 4, 5
      RX_WIN = 64


      def sdiff(a, b):
          """a - b in 16-bit sequence space, -32768..32767."""
          return ((a - b + 0x8000) & 0xFFFF) - 0x8000


      class _Seg:
          __slots__ = ("data", "flags", "ref", "n_tx", "t_sent", "acked", "dead", "fast", "need", "on_air", "t_q", "hold")

          def __init__(self, data, flags, ref):
              self.data, self.flags, self.ref = data, flags, ref
              self.n_tx, self.t_sent, self.acked, self.dead, self.fast = 0, 0.0, False, False, False
              self.on_air, self.t_q, self.hold = False, 0.0, 0.0  # v6.8: t_sent = time the CSMA released it (on_air), t_q = handed over
              self.need = True                    # waiting to be (re)sent


      class _TxPeer:
          def __init__(self, init_rto, window):
              self.cwnd = window                  # segments allowed in flight now (halved on timeout, +1 per ACK)
              self.next_seq = 0
              self.base = 0
              self.segs = collections.OrderedDict()   # seq -> _Seg, from base upwards
              self.bytes = 0
              self.srtt = None
              self.rttvar = 0.0
              self.rto = init_rto
              self.rack = 0.0                     # v6.8: latest on-air time of any acknowledged segment
              self.st = collections.Counter()


      class _RxPeer:
          def __init__(self, session, expected):
              self.session = session
              self.expected = expected
              self.buf = {}
              self.reasm = None
              self.n_since_ack = 0
              self.ack_due = None
              self.last_ack = 0.0
              self.st = collections.Counter()


      class _Client:
          def __init__(self, sock):
              self.sock = sock
              self.inbuf = bytearray()
              self.outbuf = bytearray()


      class ArqTransport(gr.basic_block):
          def __init__(self, src_id=1, port=5100, bind_addr="127.0.0.1", mss=1000, window=8, ack_every=4,
                       ack_delay_s=0.5, init_rto_s=2.0, min_rto_s=1.0, max_rto_s=8.0, max_retries=8,
                       max_msg_bytes=4194304, max_queue_bytes=8388608, rx_keep_msgs=1000, verbose=1, stats_every_s=10.0):
              gr.basic_block.__init__(self, name="ARQ Transport (TCP-like, socket)", in_sig=None, out_sig=None)
              self.src_id = int(src_id)
              self.port = int(port)
              self.bind_addr = str(bind_addr)
              self.mss = max(16, int(mss))
              self.window = max(1, min(32, int(window)))
              self.ack_every = max(1, int(ack_every))
              self.ack_delay_s = float(ack_delay_s)
              self.init_rto_s = float(init_rto_s)
              self.min_rto_s = float(min_rto_s)
              self.max_rto_s = float(max_rto_s)
              self.max_retries = max(1, int(max_retries))
              self.max_msg_bytes = int(max_msg_bytes)
              self.max_queue_bytes = int(max_queue_bytes)
              self.rx_keep_msgs = int(rx_keep_msgs)
              self.verbose = int(verbose)
              self.stats_every_s = float(stats_every_s)

              self.session = 0
              self._tx = {}                 # dest -> _TxPeer
              self._rx = {}                 # src  -> _RxPeer
              self._msgs = {}               # (dest, ref) -> {"client", "left", "failed", "segs", "t0", "size"}
              self._clients = {}
              self._kept = collections.deque()
              self._inq = collections.deque()
              self._sel = None
              self._lsock = None
              self._wake_r = self._wake_w = None
              self._thr = None
              self._run = False
              self._t_stats = 0.0
              self._loop_beat = 0.0                 # telemetry: last pass of the worker loop

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self._on_pdu)
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("mac_ctrl"))
              self.message_port_register_in(pmt.intern("mac_in"))
              self.set_msg_handler(pmt.intern("mac_in"), self._on_mac_in)
              self.mac_wait_s = 15.0                # a frame never reported by the CSMA counts as sent after this
              self._mac_fb = False                  # True once the CSMA reports frames going on air

          # ================================================================== GNU Radio side
          def start(self):
              self.session = random.getrandbits(32)
              self._sel = selectors.DefaultSelector()
              self._lsock = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
              self._lsock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
              try:
                  self._lsock.bind((self.bind_addr, self.port))
              except OSError as e:
                  print(f"[ARQ] cannot listen on {self.bind_addr}:{self.port}: {e}. Daemon socket disabled.", flush=True)
                  self._lsock.close()
                  self._lsock = None
              if self._lsock is not None:
                  self._lsock.listen(8)
                  self._lsock.setblocking(False)
                  self._sel.register(self._lsock, selectors.EVENT_READ, "listen")
              self._wake_r, self._wake_w = socket.socketpair()
              self._wake_r.setblocking(False)
              self._wake_w.setblocking(False)
              self._sel.register(self._wake_r, selectors.EVENT_READ, "wake")
              self._run = True
              self._t_stats = time.monotonic()
              self._thr = threading.Thread(target=self._loop, name="arq", daemon=True)
              self._thr.start()
              _cdp_register("arq", self)
              print(f"[ARQ] node {self.src_id}: daemon socket tcp://{self.bind_addr}:{self.port}, mss {self.mss} B, "
                    f"window {self.window}, session {self.session:08x}", flush=True)
              return True

          def stop(self):
              self._run = False
              self._wake()
              if self._thr is not None:
                  self._thr.join(timeout=2.0)
              for c in list(self._clients.values()):
                  try:
                      c.sock.close()
                  except OSError:
                      pass
              for s in (self._lsock, self._wake_r, self._wake_w):
                  if s is not None:
                      try:
                          s.close()
                      except OSError:
                          pass
              return True

          def _on_pdu(self, msg):
              """GNU Radio thread: keep only our packets, hand them to the worker."""
              try:
                  meta, data = pmt.car(msg), pmt.cdr(msg)
                  if not pmt.is_u8vector(data):
                      return
                  raw = bytes(pmt.u8vector_elements(data))
                  if len(raw) < 2 or raw[0] != MAGIC or raw[1] not in (P_DATA, P_ACK):
                      return
                  src = pmt.to_long(pmt.dict_ref(meta, pmt.intern("src_id"), pmt.from_long(-1)))
              except Exception:
                  return
              if src < 0:
                  return
              self._inq.append((src, raw))
              self._wake()

          def _on_mac_in(self, msg):
              """GNU Radio thread: the CSMA released one of our frames to the air."""
              try:
                  tag = pmt.symbol_to_string(msg) if pmt.is_symbol(msg) else str(pmt.to_python(msg))
              except Exception:
                  return
              if tag.startswith("arq:"):
                  self._inq.append((None, tag))
                  self._wake()

          def _on_air(self, tag, now):
              try:
                  _, session, dest, seq, ntx = tag.split(":")
                  if int(session, 16) != self.session:
                      return
                  tp = self._tx.get(int(dest))
                  sg = tp.segs.get(int(seq)) if tp is not None else None
              except (ValueError, AttributeError):
                  return
              self._mac_fb = True
              if sg is not None and sg.n_tx == int(ntx) and not sg.on_air:
                  sg.t_sent, sg.on_air = now, True

          def _wake(self):
              try:
                  self._wake_w.send(b"x")
              except (OSError, AttributeError):
                  pass

          def _send_air(self, dest, raw, tag=None, prio=False):
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(int(dest)))
              if tag:
                  meta = pmt.dict_add(meta, pmt.intern("arq_tag"), pmt.intern(tag))
              if prio:
                  meta = pmt.dict_add(meta, pmt.intern("prio"), pmt.from_long(1))
              self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, pmt.init_u8vector(len(raw), list(raw))))

          def _mac(self, word):
              self.message_port_pub(pmt.intern("mac_ctrl"), pmt.intern(word))

          # ================================================================== worker thread
          def telemetry(self):
              """Read-only snapshot (called from the Telemetry thread; tolerate concurrent changes)."""
              now = time.monotonic()
              peers = {}
              for dest, tp in list(self._tx.items()):
                  try:
                      segs = list(tp.segs.values())
                      live = [sg for sg in segs if sg.n_tx and not (sg.acked or sg.dead)]
                      oldest = min((sg.t_sent for sg in live), default=None)
                      msgs = [m for (d, _), m in list(self._msgs.items()) if d == dest]
                      peers[str(dest)] = {
                          "msgs": tp.st["msgs"], "sent": tp.st["sent"], "failed": tp.st["failed"], "tx": tp.st["tx"],
                          "retx": tp.st["retx"], "fast": tp.st["fast"], "timeouts": tp.st["timeouts"],
                          "inflight": sum(1 for sg in live if not sg.need), "waiting": sum(1 for sg in segs if sg.need),
                          "not_on_air": sum(1 for sg in live if not sg.need and not sg.on_air),
                          "queued_bytes": tp.bytes, "cwnd": tp.cwnd, "srtt_s": tp.srtt, "rto_s": tp.rto,
                          "max_tries_now": max((sg.n_tx for sg in live), default=0),
                          "oldest_unacked_s": (now - oldest) if oldest else 0.0,
                          "oldest_msg_s": max((now - m["t0"] for m in msgs), default=0.0), "open_msgs": len(msgs)}
                  except Exception as e:
                      peers[str(dest)] = {"error": repr(e)}
              rx = {}
              for src, st in list(self._rx.items()):
                  rx[str(src)] = {"delivered": st.st["delivered"], "bytes": st.st["bytes"], "dup": st.st["dup"],
                                  "acks": st.st["acks"], "skipped": st.st["skipped"], "discarded": st.st["discarded"],
                                  "out_of_order": len(st.buf), "partial_bytes": len(st.reasm) if st.reasm else 0}
              return {"tx": peers, "rx": rx, "mac_feedback": self._mac_fb, "clients": len(self._clients), "kept": len(self._kept),
                      "loop_age_s": (now - self._loop_beat) if self._loop_beat else None,
                      "inq": len(self._inq), "mss": self.mss, "window": self.window, "max_retries": self.max_retries,
                      "min_rto_s": self.min_rto_s, "max_rto_s": self.max_rto_s, "init_rto_s": self.init_rto_s,
                      "ack_every": self.ack_every, "ack_delay_s": self.ack_delay_s, "socket": self._lsock is not None}

          def _loop(self):
              while self._run:
                  self._loop_beat = time.monotonic()
                  for key, ev in self._sel.select(timeout=0.02):
                      try:
                          if key.data == "listen":
                              self._accept()
                          elif key.data == "wake":
                              try:
                                  while self._wake_r.recv(4096):
                                      pass
                              except (BlockingIOError, OSError):
                                  pass
                          else:
                              self._client_io(key.data, ev)
                      except Exception as e:
                          print(f"[ARQ] socket error: {e!r}", flush=True)
                  now = time.monotonic()
                  while self._inq:
                      src, raw = self._inq.popleft()
                      try:
                          if src is None:
                              self._on_air(raw, now)
                          elif raw[1] == P_DATA:
                              self._on_data(src, raw, now)
                          else:
                              self._on_ack(src, raw, now)
                      except Exception as e:
                          print(f"[ARQ] bad packet from {src}: {e!r}", flush=True)
                  self._timers(now)
                  if self.verbose and self.stats_every_s > 0 and now - self._t_stats >= self.stats_every_s:
                      self._t_stats = now
                      self._print_stats()

          # ------------------------------------------------------------------ daemon sockets
          def _accept(self):
              while True:
                  try:
                      s, addr = self._lsock.accept()
                  except (BlockingIOError, OSError):
                      return
                  s.setblocking(False)
                  c = _Client(s)
                  self._clients[s] = c
                  self._sel.register(s, selectors.EVENT_READ, c)
                  self._emit(c, struct.pack(">BBHBI", E_HELLO, self.src_id & 0xFF, self.mss, self.window,
                                            self.max_msg_bytes))
                  if self.verbose:
                      print(f"[ARQ] daemon connected from {addr[0]}:{addr[1]}", flush=True)
                  while self._kept:
                      self._emit(c, self._kept.popleft())

          def _drop_client(self, c):
              try:
                  self._sel.unregister(c.sock)
              except Exception:
                  pass
              try:
                  c.sock.close()
              except OSError:
                  pass
              self._clients.pop(c.sock, None)
              if self.verbose:
                  print("[ARQ] daemon disconnected", flush=True)

          def _client_io(self, c, ev):
              if ev & selectors.EVENT_READ:
                  try:
                      data = c.sock.recv(262144)
                  except (BlockingIOError, InterruptedError):
                      data = None
                  except OSError:
                      data = b""
                  if data == b"":
                      self._drop_client(c)
                      return
                  if data:
                      c.inbuf += data
                      self._parse_client(c)
              if ev & selectors.EVENT_WRITE and c.sock in self._clients:
                  self._flush(c)

          def _parse_client(self, c):
              while len(c.inbuf) >= 4:
                  n = int.from_bytes(c.inbuf[:4], "big")
                  if n > self.max_msg_bytes + 64:
                      print(f"[ARQ] daemon frame of {n} B is too large; closing that connection", flush=True)
                      self._drop_client(c)
                      return
                  if len(c.inbuf) < 4 + n:
                      return
                  body = bytes(c.inbuf[4:4 + n])
                  del c.inbuf[:4 + n]
                  if len(body) >= 6 and body[0] == C_SEND:
                      ref = int.from_bytes(body[1:5], "big")
                      self._submit(c, ref, body[5], body[6:])

          def _emit(self, c, body):
              c.outbuf += len(body).to_bytes(4, "big") + body
              self._flush(c)

          def _flush(self, c):
              try:
                  while c.outbuf:
                      k = c.sock.send(c.outbuf)
                      del c.outbuf[:k]
              except (BlockingIOError, InterruptedError):
                  pass
              except OSError:
                  self._drop_client(c)
                  return
              try:
                  self._sel.modify(c.sock, selectors.EVENT_READ | (selectors.EVENT_WRITE if c.outbuf else 0), c)
              except Exception:
                  pass

          def _deliver(self, src, msg):
              body = bytes([E_RECV, src & 0xFF]) + msg
              if self._clients:
                  for c in list(self._clients.values()):
                      self._emit(c, body)
              else:
                  self._kept.append(body)
                  while len(self._kept) > self.rx_keep_msgs:
                      self._kept.popleft()

          # ------------------------------------------------------------------ sending
          def _fail_now(self, c, ref, dest, reason):
              if c is not None and c.sock in self._clients:
                  self._emit(c, struct.pack(">BIBB", E_FAIL, ref, dest & 0xFF, reason))

          def _submit(self, c, ref, dest, msg):
              if not 0 <= dest <= 254 or dest == self.src_id:
                  return self._fail_now(c, ref, dest, FAIL_DEST)
              if not msg:
                  return self._fail_now(c, ref, dest, FAIL_EMPTY)
              if len(msg) > self.max_msg_bytes:
                  return self._fail_now(c, ref, dest, FAIL_SIZE)
              tp = self._tx.get(dest)
              if tp is None:
                  tp = self._tx[dest] = _TxPeer(self.init_rto_s, self.window)
              if tp.bytes + len(msg) > self.max_queue_bytes:
                  return self._fail_now(c, ref, dest, FAIL_QUEUE)
              n = -(-len(msg) // self.mss)
              seqs = []
              for i in range(n):
                  flags = (F_FIRST if i == 0 else 0) | (F_LAST if i == n - 1 else 0)
                  seq = tp.next_seq
                  tp.next_seq = (tp.next_seq + 1) & 0xFFFF
                  tp.segs[seq] = _Seg(msg[i * self.mss:(i + 1) * self.mss], flags, ref)
                  seqs.append(seq)
              tp.bytes += len(msg)
              self._msgs[(dest, ref)] = {"client": c, "left": n, "failed": False, "segs": seqs,
                                         "t0": time.monotonic(), "size": len(msg)}
              tp.st["msgs"] += 1
              if self.verbose >= 2:
                  print(f"[ARQ] message ref {ref} to node {dest}: {len(msg)} B in {n} segments", flush=True)

          def _xmit(self, dest, tp, seq, sg, now, ack_now=False):
              hdr = DATA_HDR.pack(MAGIC, P_DATA, self.session, seq, tp.base, sg.flags | (F_ACKNOW if ack_now else 0))
              tag = f"arq:{self.session:08x}:{dest}:{seq}:{sg.n_tx + 1}"
              self._send_air(dest, hdr + sg.data, tag=tag, prio=sg.n_tx > 0)
              sg.n_tx += 1
              sg.t_sent = sg.t_q = now
              sg.on_air = not self._mac_fb         # without CSMA feedback: timer starts now (v6.7 behaviour)
              sg.need = False
              tp.st["tx"] += 1
              if sg.n_tx > 1:
                  tp.st["retx"] += 1

          def _fail_msg(self, dest, tp, ref, reason):
              m = self._msgs.get((dest, ref))
              if m is None or m["failed"]:
                  return
              m["failed"] = True
              for s in m["segs"]:
                  sg = tp.segs.get(s)
                  if sg is not None and not sg.acked:
                      sg.dead = True
                      tp.bytes -= len(sg.data)
              self._fail_now(m["client"], ref, dest, reason)
              tp.st["failed"] += 1
              self._msgs.pop((dest, ref), None)
              print(f"[ARQ] message ref {ref} to node {dest} FAILED (no ACK after {self.max_retries} tries)", flush=True)

          def _advance_base(self, tp):
              while tp.segs:
                  seq, sg = next(iter(tp.segs.items()))
                  if not (sg.acked or sg.dead):
                      break
                  tp.segs.popitem(last=False)
                  tp.base = (seq + 1) & 0xFFFF
              if not tp.segs:
                  tp.base = tp.next_seq

          def _on_ack(self, src, raw, now):
              _, _, session, cum, sack = ACK_PKT.unpack(raw[:ACK_PKT.size])
              tp = self._tx.get(src)
              if tp is None or session != self.session:
                  return
              progress = False
              for seq, sg in list(tp.segs.items()):
                  if sg.acked or sg.dead:
                      continue
                  d = sdiff(seq, cum)
                  hit = d < 0 or (0 < d <= 32 and (sack >> (d - 1)) & 1)
                  if not hit:
                      continue
                  sg.acked = True
                  progress = True
                  if sg.on_air and self._mac_fb:
                      tp.rack = max(tp.rack, sg.t_sent)
                  tp.bytes -= len(sg.data)
                  if sg.n_tx == 1 and sg.on_air:
                      self._rtt_sample(tp, now - sg.t_sent)
                  m = self._msgs.get((src, sg.ref))
                  if m is not None:
                      m["left"] -= 1
                      if m["left"] == 0:
                          c = m["client"]
                          if c is not None and c.sock in self._clients:
                              self._emit(c, struct.pack(">BIB", E_SENT, sg.ref, src & 0xFF))
                          tp.st["sent"] += 1
                          if self.verbose:
                              dt = now - m["t0"]
                              print(f"[ARQ] message ref {sg.ref} to node {src} confirmed: {m['size']} B in {dt:.1f} s "
                                    f"({m['size'] / max(dt, 1e-6) / 1e3:.2f} kB/s)", flush=True)
                          self._msgs.pop((src, sg.ref), None)
              if progress:
                  tp.rto = self._rto(tp)
                  tp.cwnd = min(self.window, tp.cwnd + 1)
                  self._mac("ok")
              if self._mac_fb:
                  # v6.8 loss detection by on-air time (one shared channel delivers in order): a segment that went on
                  # air BEFORE one the receiver confirmed, and is not confirmed itself, was lost -> send it again now.
                  # Works for every hole at once, again for a lost resend, and for the tail after a timeout probe.
                  for seq, sg in tp.segs.items():
                      if not (sg.acked or sg.dead or sg.need) and sg.n_tx > 0 and sg.on_air and sg.t_sent < tp.rack - 1e-4:
                          sg.fast, sg.need, sg.hold = True, True, 0.0
                          tp.st["fast"] += 1
              # SACK-based early retransmission (no CSMA feedback): holes below the highest segment the receiver has
              elif sack:
                  high = (cum + sack.bit_length()) & 0xFFFF
                  guard = max(0.2, 0.5 * (tp.srtt or self.init_rto_s))
                  for seq, sg in tp.segs.items():
                      if sdiff(seq, high) >= 0:
                          break
                      if not (sg.acked or sg.dead or sg.need) and sg.n_tx > 0 and not sg.fast and sg.on_air \
                              and now - sg.t_sent > guard:
                          sg.fast, sg.need = True, True           # lost: send again at the next _pump
                          tp.st["fast"] += 1
              self._advance_base(tp)
              self._pump(src, tp, now)

          def _rtt_sample(self, tp, r):
              if tp.srtt is None:
                  tp.srtt, tp.rttvar = r, r / 2
              else:
                  tp.rttvar = 0.75 * tp.rttvar + 0.25 * abs(tp.srtt - r)
                  tp.srtt = 0.875 * tp.srtt + 0.125 * r

          def _rto(self, tp):
              if tp.srtt is None:
                  return self.init_rto_s
              return min(self.max_rto_s, max(self.min_rto_s, tp.srtt + 4 * tp.rttvar))

          # ------------------------------------------------------------------ receiving
          def _on_data(self, src, raw, now):
              _, _, session, seq, base, flags = DATA_HDR.unpack(raw[:DATA_HDR.size])
              data = raw[DATA_HDR.size:]
              st = self._rx.get(src)
              if st is None or st.session != session:
                  if st is not None and self.verbose:
                      print(f"[ARQ] node {src} restarted (new session {session:08x}): receive state reset", flush=True)
                  st = self._rx[src] = _RxPeer(session, base)
              while sdiff(base, st.expected) > 0:                  # sender will never resend below base
                  if st.expected in st.buf:
                      self._consume(src, st)
                  else:                                            # abandoned segment: its message is lost
                      if st.reasm is not None:
                          st.st["discarded"] += 1
                      st.reasm = None
                      st.st["skipped"] += 1
                      st.expected = (st.expected + 1) & 0xFFFF
              d = sdiff(seq, st.expected)
              dup = False
              if d < 0 or seq in st.buf:
                  st.st["dup"] += 1
                  dup = True
              elif d >= RX_WIN:
                  st.st["outside"] += 1
              else:
                  st.buf[seq] = (flags, data)
                  while st.expected in st.buf:
                      self._consume(src, st)
              st.n_since_ack += 1
              if flags & F_ACKNOW or st.n_since_ack >= self.ack_every:   # (also for a duplicate: answer a probe at once)
                  self._send_ack(src, st, now)
              elif dup:                                            # sender is resending: our ACK got lost, repeat it soon
                  due = max(now, st.last_ack + self.ack_delay_s)
                  st.ack_due = due if st.ack_due is None else min(st.ack_due, due)
              elif st.ack_due is None:
                  st.ack_due = now + self.ack_delay_s              # at the latest ack_delay_s after this segment

          def _consume(self, src, st):
              """Take segment 'expected' from the buffer and add it to the message being rebuilt."""
              f, dd = st.buf.pop(st.expected)
              st.expected = (st.expected + 1) & 0xFFFF
              if f & F_FIRST:
                  if st.reasm is not None:
                      st.st["discarded"] += 1
                  st.reasm = bytearray()
              if st.reasm is None:
                  return                                           # middle of a message we lost the start of
              st.reasm += dd
              if len(st.reasm) > self.max_msg_bytes:
                  st.reasm = None
                  st.st["discarded"] += 1
                  return
              if f & F_LAST:
                  self._deliver(src, bytes(st.reasm))
                  st.st["delivered"] += 1
                  st.st["bytes"] += len(st.reasm)
                  st.reasm = None

          def _send_ack(self, src, st, now):
              sack = 0
              for s in st.buf:
                  d = sdiff(s, st.expected)
                  if 1 <= d <= 32:
                      sack |= 1 << (d - 1)
              self._send_air(src, ACK_PKT.pack(MAGIC, P_ACK, st.session, st.expected, sack), prio=True)
              st.n_since_ack, st.ack_due, st.last_ack = 0, None, now
              st.st["acks"] += 1

          # ------------------------------------------------------------------ timers
          def _timers(self, now):
              for src, st in self._rx.items():
                  if st.ack_due is not None and now >= st.ack_due:
                      self._send_ack(src, st, now)
              for dest, tp in self._tx.items():
                  if not tp.segs:
                      continue
                  late = [(seq, sg) for seq, sg in tp.segs.items()
                          if sg.n_tx and not (sg.acked or sg.dead or sg.need)
                          and now >= sg.hold
                          and ((sg.on_air and now - sg.t_sent >= tp.rto) or (not sg.on_air and now - sg.t_q >= self.mac_wait_s))]
                  if late:
                      # Timeout: only the oldest overdue segment is sent again (with ACK now). The ACK it brings back has
                      # the whole receive state: real holes are then resent early, a lost ACK costs one duplicate.
                      # The other overdue segments wait one (doubled) RTO for that ACK before they time out themselves
                      # (their send time is kept, so the ACK can still trigger their early resend).
                      late[0][1].need, late[0][1].fast = True, False
                      for seq, sg in late[1:]:
                          sg.hold = now + min(self.max_rto_s, tp.rto * 2)
                      tp.rto = min(self.max_rto_s, tp.rto * 2)
                      tp.cwnd = max(2, tp.cwnd // 2)
                      tp.st["timeouts"] += 1
                      self._mac("fail")
                  self._advance_base(tp)
                  self._pump(dest, tp, now)

          def _pump(self, dest, tp, now):
              """Send what is waiting (retransmissions first, oldest first), keeping at most cwnd segments in flight."""
              inflight = sum(1 for sg in tp.segs.values() if sg.n_tx and not (sg.acked or sg.dead or sg.need))
              burst = []
              for seq, sg in tp.segs.items():
                  if inflight + len(burst) >= min(tp.cwnd, self.window) or sdiff(seq, tp.base) >= self.window:
                      break
                  if not sg.need or sg.acked or sg.dead:
                      continue
                  if sg.n_tx >= self.max_retries:
                      self._fail_msg(dest, tp, sg.ref, FAIL_RETRIES)
                      continue
                  burst.append((seq, sg))
              for i, (seq, sg) in enumerate(burst):                     # last of the burst asks for an ACK
                  self._xmit(dest, tp, seq, sg, now, ack_now=(i == len(burst) - 1))
              if burst:
                  self._advance_base(tp)

          def _print_stats(self):
              parts = []
              for dest, tp in self._tx.items():
                  infl = sum(1 for sg in tp.segs.values() if sg.n_tx and not (sg.acked or sg.dead or sg.need))
                  srtt = f"{tp.srtt:.2f}" if tp.srtt is not None else "-"
                  parts.append(f"to {dest}: msgs {tp.st['msgs']} sent {tp.st['sent']} failed {tp.st['failed']}, "
                               f"segs tx {tp.st['tx']} retx {tp.st['retx']} (early {tp.st['fast']}), in flight {infl}, "
                               f"queued {sum(1 for sg in tp.segs.values() if not sg.n_tx)}, cwnd {tp.cwnd}, srtt {srtt} s rto {tp.rto:.2f} s")
              for src, st in self._rx.items():
                  parts.append(f"from {src}: delivered {st.st['delivered']} msgs / {st.st['bytes']} B, dup {st.st['dup']}, "
                               f"acks {st.st['acks']}, discarded {st.st['discarded']}, skipped {st.st['skipped']}")
              if parts:
                  print(f"[ARQ] {len(self._clients)} daemon(s) | " + " | ".join(parts), flush=True)
    ack_delay_s: SET_ARQ_ACK_DELAY
    ack_every: SET_ARQ_ACK_EVERY
    bind_addr: os.environ.get('CDP_BIND', '127.0.0.1')
    comment: 'v6.8: retransmission timer starts when the CSMA reports the frame on air; loss detection by on-air order; timeout resends only the oldest segment.'
    init_rto_s: SET_ARQ_INIT_RTO
    max_msg_bytes: '4194304'
    max_queue_bytes: '8388608'
    max_retries: SET_ARQ_RETRIES
    max_rto_s: SET_ARQ_MAX_RTO
    min_rto_s: SET_ARQ_MIN_RTO
    mss: SET_ARQ_MSS
    port: int(os.environ.get('CDP_ARQ_PORT', '5100'))
    rx_keep_msgs: '1000'
    src_id: MY_ID
    stats_every_s: '10.0'
    verbose: '1'
    window: SET_ARQ_WINDOW
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Test Traffic TX  (packet generator + TX log)

      Connect:  msg_out  ->  Packet Framer TX  msg_in      (the QT message edit box can stay connected too)

      Sends test packets following a test plan and writes one CSV row per packet (wall-clock timestamp
      and the exact payload) to  <log_dir>/tx_<date>_<time>_run<id>.csv

      test_plan (string):  "SIZExCOUNT@INTERVAL; SIZExCOUNT@INTERVAL; ..."
          "20x50@0.5; 200x50@0.5; 1000x50@1; 2000x30@1.5"
          SIZE      payload bytes, including the 8-byte test header (min 8, max max_payload_len)
          COUNT     packets in this set
          INTERVAL  seconds between packet starts; "ms" suffix allowed: 100x50@250ms
          optional set names:  "short:20x50@0.5; long:2000x30@1.5"
        A Python list also works:  [(20, 50, 0.5), (200, 50, 0.5, "medium")]

      Payload = [A5 5A][run_id: 2 B][seq: 4 B][fill]
          payload_mode "ascii"  : readable text (default; keeps the framer/deframer console prints clean)
                       "random" : reproducible pseudo-random bytes (most representative for the PHY)
                       "fixed"  : fill_byte repeated
      The RX logger and analyze_link.py match packets by (run_id, seq).

      A run starts start_delay seconds after the flowgraph starts (autostart=1), or whenever any message
      arrives on the ctrl port (e.g. a QT GUI Msg Push Button). A ctrl message containing "stop" ends the run.
      Each run gets a new random run_id and its own log file.
      Timestamps are wall-clock (time.time) in microseconds; keep both PCs NTP-synced for one-way latency.
      Note: the timestamp is when the packet is handed to the framer, not when it is on air. If the interval
      is shorter than the airtime, packets queue in the TX chain and the measured latency grows.
      """
      import csv
      import datetime
      import os
      import re
      import socket
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr

      MAGIC = b"\xA5\x5A"
      TEST_HDR_LEN = 8                       # magic(2) + run_id(2) + seq(4)
      ASCII_TEXT = b"The quick brown fox jumps over the lazy dog 0123456789. "
      TX_FIELDS = ["run_id", "seq", "loop", "set_idx", "set_name", "size", "interval_s",
                   "tx_time_us", "tx_time_iso", "late_ms", "host", "payload_mode", "payload_hex"]


      def parse_plan(plan):
          """Returns [(name, size, count, interval_s), ...] from a plan string or list."""
          entries = []
          if isinstance(plan, str):
              items = [s.strip() for s in re.split(r"[;\n]", plan) if s.strip()]
              for i, item in enumerate(items):
                  name = None
                  if ":" in item:
                      name, item = item.split(":", 1)
                      name = name.strip() or None
                  m = re.fullmatch(r"\s*(\d+)\s*[xX*]\s*(\d+)\s*@\s*([0-9]*\.?[0-9]+)\s*(ms|s)?\s*", item)
                  if not m:
                      raise ValueError(f"test_plan entry '{item}': use SIZExCOUNT@INTERVAL, e.g. 100x50@0.5")
                  size, count, iv = int(m.group(1)), int(m.group(2)), float(m.group(3))
                  if m.group(4) == "ms":
                      iv /= 1000.0
                  entries.append((name or f"set{i}_{size}B", size, count, iv))
          else:
              for i, e in enumerate(plan):
                  if isinstance(e, dict):
                      size, count, iv, name = int(e["size"]), int(e["count"]), float(e["interval"]), e.get("name")
                  else:
                      size, count, iv = int(e[0]), int(e[1]), float(e[2])
                      name = str(e[3]) if len(e) > 3 else None
                  entries.append((name or f"set{i}_{size}B", size, count, iv))
          return entries


      class TestTrafficTX(gr.basic_block):
          def __init__(self, test_plan="20x50@0.5; 200x50@0.5; 1000x50@1.0", repeat_plan=1,
                       start_delay=5.0, set_gap=2.0, payload_mode="ascii", fill_byte=0x55,
                       max_payload_len=2048, log_dir="~/link_tests", autostart=1):
              gr.basic_block.__init__(self, name="Test Traffic TX", in_sig=None, out_sig=None)
              self.test_plan = test_plan
              self.repeat_plan = max(1, int(repeat_plan))
              self.start_delay = max(0.0, float(start_delay))
              self.set_gap = max(0.0, float(set_gap))
              self.payload_mode = str(payload_mode).lower()
              self.fill_byte = int(fill_byte) & 0xFF
              self.max_payload_len = int(max_payload_len)
              self.log_dir = str(log_dir)
              self.autostart = int(autostart)
              if self.payload_mode not in ("ascii", "random", "fixed"):
                  raise ValueError("payload_mode must be 'ascii', 'random' or 'fixed'")
              self._plan = self._checked_plan(test_plan)       # a bad plan raises here -> visible in GRC
              self._host = socket.gethostname()
              self._thread = None
              self._stop_evt = threading.Event()
              self._lock = threading.Lock()

              self._port_out = pmt.intern("msg_out")
              self.message_port_register_out(self._port_out)
              self.message_port_register_in(pmt.intern("ctrl"))
              self.set_msg_handler(pmt.intern("ctrl"), self._handle_ctrl)

          # ---------------------------------------------------------------- plan
          def _checked_plan(self, plan):
              out = []
              for name, size, count, iv in parse_plan(plan):
                  s = max(size, TEST_HDR_LEN)
                  if self.max_payload_len > 0:
                      s = min(s, self.max_payload_len)
                  if s != size:
                      print(f"[TEST TX] set '{name}': size {size} B -> {s} B "
                            f"(min {TEST_HDR_LEN}, max {self.max_payload_len})", flush=True)
                  if count <= 0 or iv < 0:
                      raise ValueError(f"set '{name}': count must be > 0 and interval >= 0")
                  out.append((name, s, count, iv))
              if not out:
                  raise ValueError("test_plan is empty")
              return out

          # ---------------------------------------------------------------- run control
          def start(self):
              if self.autostart:
                  self._launch(self.start_delay)
              return True

          def stop(self):
              self._halt()
              return True

          def _launch(self, delay):
              with self._lock:
                  self._halt_locked()
                  self._stop_evt = threading.Event()
                  self._thread = threading.Thread(target=self._run_safe, args=(delay, self._stop_evt), daemon=True)
                  self._thread.start()

          def _halt(self):
              with self._lock:
                  return self._halt_locked()

          def _halt_locked(self):
              running = self._thread is not None and self._thread.is_alive()
              if running:
                  self._stop_evt.set()
                  self._thread.join(timeout=3.0)
              self._thread = None
              return running

          def _handle_ctrl(self, msg):
              try:
                  if pmt.is_pair(msg):
                      txt = f"{pmt.to_python(pmt.car(msg))} {pmt.to_python(pmt.cdr(msg))}"
                  else:
                      txt = str(pmt.to_python(msg))
              except Exception:
                  txt = ""
              if "stop" in txt.lower():
                  if self._halt():
                      print("[TEST TX] run stopped by ctrl message", flush=True)
              else:
                  print("[TEST TX] new run requested by ctrl message", flush=True)
                  self._launch(0.0)

          # ---------------------------------------------------------------- payload
          def _make_payload(self, run_id, seq, size):
              hdr = MAGIC + run_id.to_bytes(2, "big") + (seq & 0xFFFFFFFF).to_bytes(4, "big")
              n = size - len(hdr)
              if n <= 0:
                  return hdr
              if self.payload_mode == "random":
                  rng = np.random.default_rng((run_id << 32) | seq)
                  fill = rng.integers(0, 256, n, dtype=np.uint8).tobytes()
              elif self.payload_mode == "ascii":
                  base = b"#%07d " % seq + ASCII_TEXT
                  fill = (base * (n // len(base) + 1))[:n]
              else:
                  fill = bytes([self.fill_byte]) * n
              return hdr + fill

          # ---------------------------------------------------------------- worker thread
          def _run_safe(self, delay, stop_evt):
              try:
                  self._run(delay, stop_evt)
              except Exception as e:                      # never die silently in a thread
                  print(f"[TEST TX] ERROR: {e!r}", flush=True)

          def _run(self, delay, stop_evt):
              if stop_evt.wait(delay):
                  return
              run_id = int.from_bytes(os.urandom(2), "big")
              d = os.path.expanduser(self.log_dir)
              os.makedirs(d, exist_ok=True)
              path = os.path.join(d, f"tx_{datetime.datetime.now():%Y%m%d_%H%M%S}_run{run_id:04x}.csv")
              total = sum(c for _, _, c, _ in self._plan) * self.repeat_plan
              print(f"[TEST TX] run {run_id:04x}: {len(self._plan)} sets x {self.repeat_plan} loop(s), "
                    f"{total} packets, log -> {path}", flush=True)

              seq, max_late, n_late = 0, 0.0, 0
              with open(path, "w", newline="") as f:
                  w = csv.writer(f)
                  w.writerow(TX_FIELDS)
                  f.flush()
                  for loop in range(self.repeat_plan):
                      for set_idx, (name, size, count, iv) in enumerate(self._plan):
                          print(f"[TEST TX] run {run_id:04x} loop {loop + 1}/{self.repeat_plan} set {set_idx + 1}/"
                                f"{len(self._plan)} '{name}': {count} x {size} B every {iv:g} s", flush=True)
                          t_next = time.monotonic()
                          for _ in range(count):
                              wait = t_next - time.monotonic()
                              if wait > 0 and stop_evt.wait(wait):
                                  print(f"[TEST TX] run {run_id:04x} stopped after {seq} packets", flush=True)
                                  return
                              late = max(0.0, -wait)
                              max_late = max(max_late, late)
                              if iv > 0 and late > 0.1 * iv:
                                  n_late += 1
                              payload = self._make_payload(run_id, seq, size)
                              t_us = time.time_ns() // 1000
                              self.message_port_pub(self._port_out,
                                                    pmt.cons(pmt.make_dict(),
                                                             pmt.init_u8vector(len(payload), list(payload))))
                              w.writerow([run_id, seq, loop, set_idx, name, size, iv, t_us,
                                          datetime.datetime.fromtimestamp(t_us / 1e6).isoformat(timespec="milliseconds"),
                                          f"{late * 1000:.2f}", self._host, self.payload_mode, payload.hex()])
                              f.flush()
                              seq += 1
                              t_next += iv
                          if self.set_gap > 0 and stop_evt.wait(self.set_gap):
                              print(f"[TEST TX] run {run_id:04x} stopped after {seq} packets", flush=True)
                              return
              msg = f"[TEST TX] run {run_id:04x} DONE: {seq} packets sent, max scheduling lateness {max_late * 1000:.1f} ms"
              if n_late:
                  msg += f" ({n_late} packets >10% of their interval late: this PC cannot keep that rate)"
              print(msg, flush=True)
    autostart: '1'
    fill_byte: '"FF"'
    log_dir: '"~/link_tests"'
    max_payload_len: max_payload_len
    payload_mode: '"ascii"'
    repeat_plan: '1'
    set_gap: '2'
    start_delay: '5'
    test_plan: '"20x50@0.5; 200x50@0.5; 1000x50@1.0"'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Burst Packet Framer TX (with equalizer training word)
      - Outputs packed byte PDUs directly to pdu_pdu_to_tagged_stream
      - Zero idle transmission between bursts
      - Frame layout: [preamble] [train word: F8 DD 42 58] [1A CF FC 1D] [len: 2B][dest_id: 1B][msg_id: 1B][rep: 1B][n_reps: 1B] [payload] [CRC32: 4B] [postamble]
      - The train word is known to the RX: the correlator (digital_corr_est_cc) finds it, tags it,
        and the linear equalizer trains on it. The deframer does not look at it (it only looks for the sync word).
      - Postamble dynamically padded so total size is a multiple of buffer_size
      - Attaches tx_sob (Start of Burst) and tx_eob (End of Burst) metadata tags
      """
      import zlib
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      # 31-bit m-sequence + 1 pad bit. MUST match TRAIN_BITS in the flowgraph (RX side).
      TRAIN_WORD = bytes([0xF8, 0xDD, 0x42, 0x58])


      class PacketFramerTX(gr.basic_block):
          def __init__(
              self,
              peer_id=1,
              preamble_len=64,
              repeat_count=5,
              max_payload_len=1024,
              preamble_byte=0xFF,
              buffer_size=512,
              postamble_byte=0x00,
              train_enable=1,
          ):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst)",
                  in_sig=None,
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.buffer_size = int(buffer_size)
              self.postamble_byte = int(postamble_byte) & 0xFF
              self.train_enable = int(train_enable)
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def handle_msg(self, msg):
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return

              if not payload:
                  return

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[: self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              preamble = bytes([self.preamble_byte]) * self.preamble_len
              train = TRAIN_WORD if self.train_enable else b""
              print(
                  f"[TX] msg #{msg_id} (to peer {self.peer_id}): '{payload.decode('utf-8', 'replace')}' ({n_reps} bursts queued)",
                  flush=True,
              )

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([self.peer_id, msg_id, rep, n_reps])
                  crc = zlib.crc32(header + payload).to_bytes(4, "big")

                  # Core frame structure before buffer alignment
                  raw_frame = preamble + train + SYNC_WORD + header + payload + crc

                  # Calculate postamble padding required to match buffer_size multiple
                  if self.buffer_size > 0:
                      rem = len(raw_frame) % self.buffer_size
                      pad_len = (self.buffer_size - rem) % self.buffer_size
                  else:
                      pad_len = 0

                  postamble = bytes([self.postamble_byte]) * pad_len
                  frame = raw_frame + postamble

                  # Build metadata dictionary with tx_sob and tx_eob tags
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("tx_sob"), pmt.PMT_T)
                  meta = pmt.dict_add(meta, pmt.intern("tx_eob"), pmt.PMT_T)

                  # Explicit offset tags for downstream PDU-to-Tagged-Stream conversion
                  sob_tag = pmt.make_tuple(pmt.from_long(0), pmt.intern("tx_sob"), pmt.PMT_T)
                  eob_tag = pmt.make_tuple(pmt.from_long(len(frame) - 1), pmt.intern("tx_eob"), pmt.PMT_T)
                  extra_tags = pmt.list2(sob_tag, eob_tag)
                  meta = pmt.dict_add(meta, pmt.intern("extra_tags"), extra_tags)

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
    buffer_size: BUFFER_SIZE
    max_payload_len: max_payload_len
    peer_id: '1'
    postamble_byte: '0xFF'
    preamble_byte: '0xFF'
    preamble_len: '128'
    repeat_count: '1'
    train_enable: '1'
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Fast Burst Packet Deframer RX (Hamming FEC) - v6.6, src / dest addressing, diagnostics
      - Transport packets (payload starting with C5, for the ARQ / UDP blocks) go out on pdu_out without the
        [RX RECEIVED] banner, burst summary or text_out message.
      - Vectorized NumPy sliding-window sync detection; positive correlation only (diff decoder resolves 180 deg)
      - fec = 0 / 15 / 31 and interleave must match the TX framer (v6.5 framer: 7-byte header with dest_id and src_id)
      - Hamming decode: header section first (gives the length), then payload+CRC section; CRC32 over header+payload
      - src_id = this node's ID (the same value its framer writes as src_id).
        Address filter: delivers frames whose dest_id == src_id or dest_id == 255 (every node); drops frames addressed
        to other nodes, and frames whose src_id == this node's (its own echo). accept_all = 1 delivers every good frame.
      - Repeat filter, per sender: a frame is a repeat only if it has the same msg_id as that sender's last message, a
        burst number not seen yet, and arrives within dup_window_s. A restarted sender (msg_id back to 0) is shown again.
      - pdu_out metadata: src_id, dest_id, msg_id, n_reps, fec_corrected

      Diagnostics (debug = 1), at most max_dbg_lines lines per second:
        [RX dbg] train word ...  for every 'corr_est' tag (the correlator found the train word), once the bits behind it
                                 have arrived: bit errors in the train word and in the sync word right after it, counted
                                 on the decoded bits (after equalizer, Costas, slicer, diff decoder, i.e. what this block
                                 gets). The deframer locks only if the sync word has <= max_bit_errors errors.
        [RX dbg] frame ...       for every sync word this block locks on: header length, CRC result, bits fixed by the
                                 FEC, squelch closures inside the frame ('squelch_eob' tags: the power squelch with
                                 gate = True dropped samples there), sender ID and what happened to the frame.
        [RX stats] ...           every stats_every_s while there is traffic: counters for each stage since the
                                 previous [RX stats] line, and good frames per sender ID.
      """
      import time
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr


      def _cdp_register(name, blk):
          """Shared registry (one per flowgraph process) read by the Telemetry block."""
          import sys as _sys, types as _types
          reg = _sys.modules.get("cdp_registry")
          if reg is None:
              reg = _types.ModuleType("cdp_registry")
              reg.blocks = {}
              _sys.modules["cdp_registry"] = reg
          reg.blocks[name] = blk

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      TRAIN_WORD = bytes([0xF8, 0xDD, 0x42, 0x58])     # must match the framer / TRAIN_BITS
      HDR_BYTES = 7  # len (2B) + dest_id (1B) + src_id (1B) + msg_id (1B) + rep (1B) + n_reps (1B)
      BROADCAST = 0xFF
      HIST_BITS = 1 << 16


      def hamming_tables(n):
          """Standard positional Hamming layout: parity bits at positions 1, 2, 4, 8, (16)."""
          m = {15: 4, 31: 5}[n]
          pos = np.arange(1, n + 1)
          is_parity = (pos & (pos - 1)) == 0
          data_idx = np.flatnonzero(~is_parity)
          H = ((pos[None, :] >> np.arange(m)[:, None]) & 1).astype(np.int32)   # m x n, column j = bin(j)
          weights = (1 << np.arange(m)).astype(np.int32)
          return data_idx, H, weights


      def hamming_decode_bits(coded, n, nblk, interleave):
          """coded: nblk*n bits. Returns (data bits nblk*k, number of corrected bits)."""
          data_idx, H, weights = hamming_tables(n)
          c = np.asarray(coded, dtype=np.int32)
          cw = c.reshape(n, nblk).T.copy() if interleave else c.reshape(nblk, n).copy()
          S = ((cw @ H.T) & 1) @ weights          # syndrome = error position (1..n), 0 = no error
          bad = np.flatnonzero(S)
          cw[bad, S[bad] - 1] ^= 1                # flip bit at position S
          return cw[:, data_idx].reshape(-1).astype(np.uint8), int(bad.size)


      def _pm(b):
          return np.unpackbits(np.frombuffer(b, np.uint8)).astype(np.int16) * 2 - 1


      class PacketDeframerRX(gr.sync_block):
          def __init__(self, src_id=1, max_bit_errors=2, max_payload_len=1024, bit_rate=375000,
                       fec=15, interleave=True, accept_all=0, debug=1, max_dbg_lines=20, stats_every_s=10.0,
                       dup_window_s=2.0):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX (Fast Burst, Hamming, src/dest)",
                  in_sig=[np.uint8],
                  out_sig=None,
              )
              self.src_id = int(src_id) & 0xFF
              self.accept_all = int(accept_all)
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.bit_rate = float(bit_rate)
              self.fec = int(fec)
              self.interleave = bool(interleave)
              self.debug = int(debug)
              self.max_dbg_lines = max(1, int(max_dbg_lines))
              self.stats_every_s = float(stats_every_s)
              self.dup_window_s = float(dup_window_s)
              if self.fec not in (0, 15, 31):
                  raise ValueError("fec must be 0, 15 or 31")

              self._sync = _pm(SYNC_WORD)
              self._train = _pm(TRAIN_WORD)
              self._buf = np.zeros(0, dtype=np.uint8)
              self._buf_abs = 0                     # absolute input index of self._buf[0]

              # decoded-bit history for the train-word check
              self._hist = np.zeros(0, dtype=np.uint8)
              self._hist_abs = 0
              self._train_pending = []              # [(abs offset, rho)]
              self._train_seen = []                 # [(abs index where the sync word should start, rho, terr, serr)]
              self._eobs = []                       # abs offsets of squelch_eob tags (recent)

              self.n_sync = 0
              self.n_ok = 0
              self.n_crc_fail = 0
              self.n_bad_len = 0
              self.n_fec_corrected = 0
              self._c = dict.fromkeys(("train", "train_clean", "train_bad_sync", "train_garbage", "lock", "bad_len",
                                       "crc_fail", "crc_fail_cut", "ok", "other", "own", "delivered", "repeat",
                                       "sq_eob"), 0)
              self._by_src = {}                     # src id -> good frames since the last stats line
              self._c_last = dict(self._c)
              self._t_stats = time.monotonic()
              self._dbg_t = 0.0
              self._dbg_n = 0
              self._dbg_dropped = 0
              self._warned_id = False
              self._own_seen = 0

              self._bits_total = 0
              self._bits_at_last_ok = 0
              self._cur_id = None
              self._cur_reps = set()
              self._cur_nreps = 0
              self._cur_corr = 0
              self._last = {}                       # src -> {"msg": msg_id, "reps": set, "t": time}
              self._last_work = 0.0                 # telemetry
              self._last_ok_wall = 0.0
              self._wait_since = None               # PC time since a sync candidate is waiting for more bits

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("text_out"))

          # ---------- start / stop ----------
          def start(self):
              _cdp_register("deframer", self)
              what = "every good frame (accept_all)" if self.accept_all else f"frames with dest ID {self.src_id} or 255 (all)"
              print(f"[RX] this node: src ID {self.src_id}; delivers {what} "
                    f"(FEC {self.fec or 'off'}, sync word may have <= {self.max_bit_errors} bit errors)", flush=True)
              return True

          def stop(self):
              self._flush_summary()
              if self.debug:
                  self._print_stats(final=True)
              return True

          # ---------- debug output ----------
          def _dbg(self, line):
              if not self.debug:
                  return
              now = time.monotonic()
              if now - self._dbg_t >= 1.0:
                  self._dbg_t, self._dbg_n = now, 0
              if self._dbg_n >= self.max_dbg_lines:
                  self._dbg_dropped += 1
                  return
              self._dbg_n += 1
              if self._dbg_dropped:
                  print(f"[RX dbg] ({self._dbg_dropped} lines not shown: more than {self.max_dbg_lines}/s)", flush=True)
                  self._dbg_dropped = 0
              print(f"[RX dbg] {line}", flush=True)

          def _print_stats(self, final=False):
              c, l = self._c, self._c_last
              d = {k: c[k] - l[k] for k in c} if not final else c
              if not final and not any(d.values()):
                  return
              span = "total" if final else "since last line"
              senders = ", ".join(f"ID {k}: {v}" for k, v in sorted(self._by_src.items())) or "none"
              print(f"[RX stats] {span}: train words {d['train']} (clean {d['train_clean']}, sync word broken "
                    f"{d['train_bad_sync']}, no train word in the bits {d['train_garbage']}) | sync locks {d['lock']} | "
                    f"bad length {d['bad_len']} | CRC fail {d['crc_fail']} (squelch closed inside {d['crc_fail_cut']}) | "
                    f"CRC ok {d['ok']}: delivered {d['delivered']}, repeats {d['repeat']}, for other nodes {d['other']}, "
                    f"own {d['own']} | good frames by src ID: {senders} | squelch closures {d['sq_eob']}", flush=True)
              self._c_last = dict(c)
              if not final:
                  self._by_src = {}

          # ---------- section sizes (in channel bits) ----------
          def _coded_len(self, n_bytes):
              if self.fec == 0:
                  return n_bytes * 8, 0
              nblk = -(-(n_bytes * 8) // {15: 11, 31: 26}[self.fec])
              return nblk * self.fec, nblk

          def _decode_section(self, coded, n_bytes, nblk):
              if self.fec == 0:
                  return np.packbits(coded).tobytes(), 0
              bits, corr = hamming_decode_bits(coded, self.fec, nblk, self.interleave)
              return np.packbits(bits[:n_bytes * 8]).tobytes(), corr

          # ---------- statistics / delivery ----------
          def _flush_summary(self):
              if self._cur_id is not None and not getattr(self, "_cur_quiet", False):
                  got, n = len(self._cur_reps), self._cur_nreps
                  loss = 100.0 * (n - got) / max(n, 1)
                  fec_txt = f", FEC corrected {self._cur_corr} bits" if self.fec else ""
                  print(f"[RX] msg #{self._cur_id}: {got}/{n} bursts OK (Loss: {loss:.0f}%){fec_txt}", flush=True)
              self._cur_id = None
              self._cur_reps = set()
              self._cur_corr = 0

          def _deliver(self, header, payload, corrected):
              """Returns 'delivered' or 'repeat'."""
              dst, sender, msg_id, rep, n_reps = header[2], header[3], header[4], header[5], header[6]
              now = time.monotonic()
              last = self._last.get(sender)
              repeat = (last is not None and last["msg"] == msg_id and rep not in last["reps"]
                        and now - last["t"] <= self.dup_window_s)
              self._bits_at_last_ok = self._bits_total
              if repeat:
                  last["reps"].add(rep)
                  last["t"] = now
                  if rep not in self._cur_reps:
                      self._cur_corr += corrected
                  self._cur_reps.add(rep)
                  return "repeat"

              self._flush_summary()
              self._last[sender] = {"msg": msg_id, "reps": {rep}, "t": now}
              self._cur_id, self._cur_nreps, self._cur_reps, self._cur_corr = msg_id, n_reps, {rep}, corrected
              self._cur_quiet = payload[:1] == b"\xC5"           # transport packet: no banner
              text = payload.decode("utf-8", errors="replace")
              to = "all" if dst == BROADCAST else f"ID {dst}"
              if not self._cur_quiet:
                  print("\n" + "=" * 40, flush=True)
                  print(f"[RX RECEIVED] #{msg_id} from src ID {sender} to {to}: {text}", flush=True)
                  print("=" * 40 + "\n", flush=True)

              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("src_id"), pmt.from_long(sender))
              meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dst))
              meta = pmt.dict_add(meta, pmt.intern("msg_id"), pmt.from_long(msg_id))
              meta = pmt.dict_add(meta, pmt.intern("n_reps"), pmt.from_long(n_reps))
              meta = pmt.dict_add(meta, pmt.intern("fec_corrected"), pmt.from_long(corrected))
              vec = pmt.init_u8vector(len(payload), list(payload))
              self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
              if not self._cur_quiet:
                  self.message_port_pub(pmt.intern("text_out"), pmt.intern(text))
              return "delivered"

          # ---------- diagnostics helpers ----------
          def _read_tags(self, n):
              try:
                  tags = self.get_tags_in_window(0, 0, n)
              except Exception:
                  return
              for t in tags:
                  try:
                      key = pmt.symbol_to_string(t.key)
                  except Exception:
                      continue
                  if key == "corr_est":
                      try:
                          rho = float(pmt.to_double(t.value))
                      except Exception:
                          rho = float("nan")
                      self._train_pending.append((int(t.offset), rho))
                      self._c["train"] += 1
                  elif key == "squelch_eob":
                      self._eobs.append(int(t.offset))
                      self._c["sq_eob"] += 1
              if len(self._eobs) > 512:
                  self._eobs = self._eobs[-256:]

          def _check_trains(self):
              """Look at the decoded bits around each correlator tag once enough bits have arrived."""
              end_abs = self._hist_abs + len(self._hist)
              keep = []
              for off, rho in self._train_pending:
                  if off + 160 > end_abs:
                      keep.append((off, rho))
                      continue
                  a = max(0, off - 64 - self._hist_abs)
                  b = off + 160 - self._hist_abs
                  seg = self._hist[a:b].astype(np.int16) * 2 - 1
                  if len(seg) < 96:
                      continue
                  c = np.lib.stride_tricks.sliding_window_view(seg[:len(seg) - 32], 32) @ self._train
                  j = int(np.argmax(c))
                  terr = (32 - int(c[j])) // 2
                  serr = (32 - int(seg[j + 32:j + 64] @ self._sync)) // 2
                  sync_abs = self._hist_abs + a + j + 32
                  self._train_seen.append((sync_abs, rho, terr, serr))
                  if terr <= 3 and serr <= self.max_bit_errors:
                      self._c["train_clean"] += 1
                      verdict = "clean, deframer can lock"
                  elif terr <= 3:
                      self._c["train_bad_sync"] += 1
                      verdict = (f"sync word has more than {self.max_bit_errors} errors -> no lock: bits go wrong right "
                                 f"after the train word (equalizer / Costas / squelch)")
                  else:
                      self._c["train_garbage"] += 1
                      verdict = ("the train word is not in the decoded bits: the demodulator output is wrong although the "
                                 "correlator saw the word (equalizer, Costas, slicer, diff decoder, DC offset)")
                  self._dbg(f"train word (corr {rho:.2f}): decoded train word {terr}/32 bits wrong, "
                            f"sync word {serr}/32 wrong -> {verdict}")
              self._train_pending = keep
              if len(self._train_seen) > 64:
                  self._train_seen = self._train_seen[-32:]

          def _cuts(self, a, b):
              return sum(1 for e in self._eobs if a < e < b)

          def _keep(self, buf, start):
              start = max(0, min(start, len(buf)))
              self._buf = buf[start:].copy()
              self._buf_abs += start

          # ---------- main loop ----------
          def telemetry(self):
              now = time.monotonic()
              return {"counters": dict(self._c), "buffer_bits": int(len(self._buf)),
                      "waiting_s": (now - self._wait_since) if self._wait_since else 0.0,
                      "last_work_age_s": (now - self._last_work) if self._last_work else None,
                      "last_ok_age_s": (now - self._last_ok_wall) if self._last_ok_wall else None,
                      "src_id": self.src_id, "max_bit_errors": self.max_bit_errors, "debug": self.debug}

          def work(self, input_items, output_items):
              self._last_work = time.monotonic()
              bits = input_items[0] & 1
              n_in = len(bits)
              self._bits_total += n_in
              if len(self._buf) == 0:
                  self._buf_abs = self.nitems_read(0)
              self._buf = np.concatenate((self._buf, bits)) if len(self._buf) else bits.copy()

              if self.debug:
                  self._read_tags(n_in)
                  if len(self._hist) == 0:
                      self._hist_abs = self.nitems_read(0)
                  self._hist = np.concatenate((self._hist, bits))
                  if len(self._hist) > HIST_BITS:
                      cut = len(self._hist) - HIST_BITS
                      self._hist = self._hist[cut:]
                      self._hist_abs += cut
                  self._check_trains()
                  if time.monotonic() - self._t_stats >= self.stats_every_s:
                      self._t_stats = time.monotonic()
                      self._print_stats()

              # Flush transmission stats once channel has been quiet for > 0.5s of air time
              if self._cur_id is not None and self._bits_total - self._bits_at_last_ok > 0.5 * self.bit_rate:
                  self._flush_summary()

              thr = 32 - 2 * self.max_bit_errors
              hdr_coded, hdr_blk = self._coded_len(HDR_BYTES)
              hdr_bits = 32 + hdr_coded

              while True:
                  buf = self._buf
                  if len(buf) < hdr_bits:
                      return n_in

                  pm = buf.astype(np.int16) * 2 - 1
                  corr = np.lib.stride_tricks.sliding_window_view(pm, 32) @ self._sync
                  cand = np.flatnonzero(corr >= thr)

                  if cand.size == 0:
                      self._keep(buf, len(buf) - 31)          # keep trailing bits that might begin a sync word
                      return n_in

                  i = int(cand[0])
                  if len(buf) < i + hdr_bits:
                      self._keep(buf, i)                      # await complete header bits
                      self._wait_since = self._wait_since or time.monotonic()
                      return n_in

                  header, hdr_corr = self._decode_section(buf[i + 32: i + hdr_bits], HDR_BYTES, hdr_blk)
                  length = int.from_bytes(header[:2], "big")
                  fa = self._buf_abs + i

                  if length == 0 or length > self.max_payload_len:
                      self.n_bad_len += 1
                      self._c["bad_len"] += 1
                      if self._near_train(fa):
                          self._dbg(f"frame: sync word found after a train word, but the header length {length} is "
                                    f"invalid (FEC fixed {hdr_corr} bits) -> header corrupted")
                      self._keep(buf, i + 1)                  # backtrack 1 bit past false sync
                      continue

                  body_coded, body_blk = self._coded_len(length + 4)
                  end = i + hdr_bits + body_coded
                  if len(buf) < end:
                      self._keep(buf, i)                      # await complete frame body bits
                      self._wait_since = self._wait_since or time.monotonic()
                      return n_in

                  self._wait_since = None
                  body, body_corr = self._decode_section(buf[i + hdr_bits: end], length + 4, body_blk)
                  payload, rx_crc = body[:length], body[length:]
                  self.n_sync += 1
                  self._c["lock"] += 1
                  fe = self._buf_abs + end
                  cuts = self._cuts(fa - 32, fe)
                  cut_txt = f", squelch closed {cuts}x inside the frame" if cuts else ""
                  corrected = hdr_corr + body_corr

                  if zlib.crc32(header + payload) == int.from_bytes(rx_crc, "big"):
                      self.n_fec_corrected += corrected
                      self.n_ok += 1
                      self._c["ok"] += 1
                      self._last_ok_wall = time.monotonic()
                      dst, sender, msg_id = header[2], header[3], header[4]
                      self._by_src[sender] = self._by_src.get(sender, 0) + 1
                      to = "all" if dst == BROADCAST else f"ID {dst}"
                      if sender == self.src_id and not self.accept_all:
                          self._c["own"] += 1
                          preview = payload[:40].decode("utf-8", errors="replace")
                          self._dbg(f"frame: {length} B, CRC ok, src ID {sender} (this node's own) -> {to}, "
                                    f"msg #{msg_id} '{preview}' -> dropped")
                          if not self._warned_id:
                              self._warned_id = True
                              print(f"[RX] WARNING: a good frame carried this node's own src ID {sender}. If this PC "
                                    f"did not just send that text, another PC uses the same CDP_MY_ID: every node needs "
                                    f"its own ID. (If it is this PC's own text, its own burst leaked past the CSMA "
                                    f"receive-off window: raise gate_guard_s.)", flush=True)
                      elif self.accept_all or dst == self.src_id or dst == BROADCAST:
                          what = self._deliver(header, payload, corrected)
                          self._c[what] += 1
                          self._dbg(f"frame: {length} B, CRC ok (FEC fixed {corrected} bits), src ID {sender} -> {to}, "
                                    f"msg #{msg_id} -> {'delivered' if what == 'delivered' else 'repeat burst, not shown again'}")
                      else:
                          self._c["other"] += 1
                          self._dbg(f"frame: {length} B, CRC ok, src ID {sender} -> {to}, msg #{msg_id} -> "
                                    f"not addressed to this node (ID {self.src_id}), dropped")
                      self._keep(buf, end)                    # advance past valid frame
                  else:
                      self.n_crc_fail += 1
                      self._c["crc_fail"] += 1
                      if cuts:
                          self._c["crc_fail_cut"] += 1
                      self._dbg(f"frame: header says {length} B, src ID {header[3]} -> dest ID {header[2]}, msg #{header[4]}, CRC FAIL "
                                f"(FEC fixed {corrected} bits, still wrong){cut_txt}")
                      self._keep(buf, i + 1)                  # backtrack 1 bit past false sync

              return n_in

          def _near_train(self, sync_abs):
              return any(abs(s - sync_abs) <= 8 for s, _, _, _ in self._train_seen)
    accept_all: '0'
    bit_rate: '375000'
    comment: 'v6.5: src_id = this node (MY_ID). Delivers frames with dest_id == src_id or 255; drops the rest and its own. accept_all=1: monitor every frame.'
    debug: SET_DEBUG
    dup_window_s: '2.0'
    fec: FEC
    interleave: 'True'
    max_bit_errors: '1'
    max_dbg_lines: '20'
    max_payload_len: max_payload_len
    src_id: MY_ID
    stats_every_s: '10.0'
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Burst Packet Framer TX (Hamming FEC + train word) - v6.6, src / dest addressing
      - Packets from the ARQ / UDP transport blocks (binary payload starting with C5) are sent without a console line;
        the transport blocks print their own summaries.
      - Outputs packed byte PDUs (to the CSMA block / PDU to Tagged Stream)
      - Frame layout:
          [preamble] [train word: F8 DD 42 58] [sync: 1A CF FC 1D] [coded header] [coded body] [postamble]
        header = [len:2B][dest_id:1B][src_id:1B][msg_id:1B][rep:1B][n_reps:1B]   (7 bytes; v6.4 had 6, no dest)
        body   = [payload][CRC32 over header+payload: 4B]
      - src_id  = this node's ID (0..254), written into every frame.
        dest_id = default destination: 0..254 one node, 255 = every node. Can be changed while running (GUI box).
        Destination of each message, first match wins:
          1. PDU metadata key "dest_id" (or "dst"), integer, e.g. set by an upper layer
          2. text messages (QT edit box) starting with "@<id> " -> that node, "@all " or "@* " -> every node;
             the prefix is removed before sending. Binary PDUs are never parsed for "@".
          3. dest_id
      - fec = 0 / 15 / 31 (Hamming), interleave = column-wise codeword order. Must match the deframer.
      - Postamble pads the frame to whole Pluto sink buffers (never shorter than one buffer).
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      # 31-bit m-sequence + 1 pad bit. MUST match TRAIN_BITS in the flowgraph (RX side).
      TRAIN_WORD = bytes([0xF8, 0xDD, 0x42, 0x58])
      BROADCAST = 0xFF


      def hamming_tables(n):
          """Standard positional Hamming layout: parity bits at positions 1, 2, 4, 8, (16)."""
          m = {15: 4, 31: 5}[n]
          pos = np.arange(1, n + 1)
          is_parity = (pos & (pos - 1)) == 0
          data_idx = np.flatnonzero(~is_parity)          # 0-based indices of data positions
          par_idx = np.flatnonzero(is_parity)            # 0-based indices of 1, 2, 4, 8, (16)
          P = ((pos[data_idx, None] >> np.arange(m)) & 1).astype(np.int32)   # k x m
          return data_idx, par_idx, P


      def hamming_encode_bits(bits, n, interleave):
          """bits: 0/1 array. Pads to a multiple of k, returns the coded bit array."""
          data_idx, par_idx, P = hamming_tables(n)
          k = len(data_idx)
          nblk = -(-len(bits) // k)
          d = np.zeros(nblk * k, dtype=np.int32)
          d[:len(bits)] = bits
          d = d.reshape(nblk, k)
          cw = np.zeros((nblk, n), dtype=np.uint8)
          cw[:, data_idx] = d
          cw[:, par_idx] = (d @ P) & 1
          return (cw.T if interleave else cw).reshape(-1)


      def id_name(i):
          return "all" if i == BROADCAST else str(i)


      class PacketFramerTX(gr.basic_block):
          def __init__(self, src_id=1, dest_id=255, preamble_len=64, repeat_count=1, max_payload_len=1024,
                       preamble_byte=0xFF, buffer_size=2048, postamble_byte=0xFF, train_enable=1,
                       fec=15, interleave=1, samples_per_byte=32):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst, FEC, src/dest)",
                  in_sig=None,
                  out_sig=None,
              )
              self.src_id = int(src_id)
              if not 0 <= self.src_id <= 254:
                  raise ValueError("src_id must be 0..254 (255 is the broadcast address)")
              self._dest_id = self._check_id(dest_id, BROADCAST)
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.buffer_size = int(buffer_size)              # Pluto sink buffer, in SAMPLES
              self.postamble_byte = int(postamble_byte) & 0xFF
              self.train_enable = int(train_enable)
              self.fec = int(fec)
              self.interleave = bool(int(interleave))
              self.samples_per_byte = max(1, int(samples_per_byte))   # 8 bits * samples/symbol (BPSK)
              if self.fec not in (0, 15, 31):
                  raise ValueError("fec must be 0, 15 or 31")
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          # dest_id is a property so the GUI box (GRC callback: blk.dest_id = value) can change it while running
          @property
          def dest_id(self):
              return self._dest_id

          @dest_id.setter
          def dest_id(self, value):
              new = self._check_id(value, None)
              if new is None:
                  return
              if new != self._dest_id:
                  self._dest_id = new
                  print(f"[TX] default destination is now ID {id_name(new)}", flush=True)

          @staticmethod
          def _check_id(value, fallback):
              try:
                  v = int(float(value))
              except (TypeError, ValueError):
                  v = -1
              if 0 <= v <= 255:
                  return v
              print(f"[TX] dest ID {value!r} ignored: use 0..254, or 255 for every node", flush=True)
              return fallback

          def start(self):
              print(f"[TX] this node: src ID {self.src_id}; messages go to dest ID {id_name(self._dest_id)} unless "
                    f"they start with '@<id> ' or '@all '", flush=True)
              return True

          # ---------- input parsing ----------
          @staticmethod
          def _extract(msg):
              """Returns (payload bytes, dst from metadata or None, is_text)."""
              meta_dst = None
              if pmt.is_pair(msg):
                  meta, data = pmt.car(msg), pmt.cdr(msg)
                  try:
                      if pmt.is_dict(meta):
                          for key in ("dest_id", "dst"):
                              v = pmt.dict_ref(meta, pmt.intern(key), pmt.PMT_NIL)
                              if pmt.is_integer(v):
                                  meta_dst = pmt.to_long(v) & 0xFF
                                  break
                  except Exception:
                      pass
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data)), meta_dst, False
                  return str(pmt.to_python(data)).encode("utf-8"), meta_dst, True
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8"), None, True
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val), None, False
              return str(val).encode("utf-8"), None, True

          @staticmethod
          def _parse_at(payload):
              """'@3 hello' -> (3, b'hello'); '@all hi' / '@* hi' -> (255, b'hi'); otherwise (None, payload)."""
              if not payload.startswith(b"@"):
                  return None, payload
              head, _, rest = payload[1:].partition(b" ")
              h = head.decode("ascii", "replace").lower()
              if h in ("all", "*"):
                  return BROADCAST, rest
              if h.isdigit() and 0 <= int(h) <= 255:
                  return int(h), rest
              return None, payload

          # ---------- frame building ----------
          def _encode_section(self, data):
              bits = np.unpackbits(np.frombuffer(data, dtype=np.uint8))
              return hamming_encode_bits(bits, self.fec, self.interleave)

          def _coded_body(self, header, payload):
              """Everything after the sync word: header + payload + CRC, coded if fec != 0."""
              crc = zlib.crc32(header + payload).to_bytes(4, "big")
              if self.fec == 0:
                  return header + payload + crc
              coded = np.concatenate((self._encode_section(header),
                                      self._encode_section(payload + crc)))
              return np.packbits(coded).tobytes()               # pads the last byte with 0s

          def _postamble_len(self, raw_len):
              """Bytes of postamble: at least one sink buffer, and total a whole number of buffers."""
              if self.buffer_size <= 0:
                  return 0
              unit = max(1, -(-self.buffer_size // self.samples_per_byte))    # bytes per sink buffer
              need = raw_len + unit                                           # leave one full buffer of postamble
              return (-(-need // unit)) * unit - raw_len

          def build_frame(self, header, payload):
              preamble = bytes([self.preamble_byte]) * self.preamble_len
              train = TRAIN_WORD if self.train_enable else b""
              raw = preamble + train + SYNC_WORD + self._coded_body(header, payload)
              return raw + bytes([self.postamble_byte]) * self._postamble_len(len(raw))

          def handle_msg(self, msg):
              try:
                  payload, dst, is_text = self._extract(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return
              if dst is None and is_text:
                  dst, payload = self._parse_at(payload)
              if dst is None:
                  dst = self._dest_id
              if dst == self.src_id:
                  print(f"[TX] message addressed to this node (ID {dst}) not sent", flush=True)
                  return
              if not payload:
                  return

              fwd = []                                   # v6.8: hand the ARQ's tag / priority on to the CSMA
              try:
                  m0 = pmt.car(msg)
                  if pmt.is_dict(m0):
                      for k in ("arq_tag", "prio"):
                          v = pmt.dict_ref(m0, pmt.intern(k), pmt.PMT_NIL)
                          if not pmt.is_null(v):
                              fwd.append((k, v))
              except Exception:
                  fwd = []

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[: self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              fec_txt = "no FEC" if self.fec == 0 else f"Hamming({self.fec},{self.fec - (4 if self.fec == 15 else 5)})"
              shown = payload.decode("utf-8", "replace") if is_text else f"{len(payload)} B binary"
              quiet = not is_text and payload[:1] == b"\xC5"
              quiet or print(f"[TX] msg #{msg_id} src ID {self.src_id} -> dest ID {id_name(dst)}: '{shown}' "
                    f"({n_reps} bursts queued, {fec_txt})", flush=True)

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([dst, self.src_id, msg_id, rep, n_reps])
                  frame = self.build_frame(header, payload)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("tx_sob"), pmt.PMT_T)
                  meta = pmt.dict_add(meta, pmt.intern("tx_eob"), pmt.PMT_T)
                  sob_tag = pmt.make_tuple(pmt.from_long(0), pmt.intern("tx_sob"), pmt.PMT_T)
                  eob_tag = pmt.make_tuple(pmt.from_long(len(frame) - 1), pmt.intern("tx_eob"), pmt.PMT_T)
                  meta = pmt.dict_add(meta, pmt.intern("extra_tags"), pmt.list2(sob_tag, eob_tag))
                  for k, v in fwd:
                      meta = pmt.dict_add(meta, pmt.intern(k), v)

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
    buffer_size: BUFFER_SIZE
    comment: 'v6.5: header [len][dest_id][src_id][msg][rep][nreps]. src_id = MY_ID. dest_id = ''Dest ID'' box (live), overridden per message by ''@N text'' / ''@all text''.'
    dest_id: DEST_ID
    fec: FEC
    interleave: 'True'
    max_payload_len: max_payload_len
    postamble_byte: '0xFF'
    preamble_byte: '0xFF'
    preamble_len: '128'
    repeat_count: '1'
    samples_per_byte: 8*sps
    src_id: MY_ID
    train_enable: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Test Traffic RX  (receive logger)

      Connect:  Packet Deframer RX  pdu_out  ->  pdu_in

      Every frame the deframer delivers is written to  <log_dir>/rx_<date>_<time>.csv  with a wall-clock
      timestamp (microseconds), the test run_id / seq when the payload carries the test header (A5 5A ...),
      the deframer's msg_id, and the payload as hex. Non-test frames (chat etc.) are logged with is_test = 0.
      One file per flowgraph start; rows are flushed immediately, so the log survives a crash or Ctrl-C.
      Prints a running count per test run (received, missing so far, delivery %).
      The deframer only delivers CRC-good frames, so this log holds correct packets only; losses are
      found by the analysis script from the gaps against the TX log.
      """
      import csv
      import datetime
      import os
      import socket
      import time

      import pmt
      from gnuradio import gr

      MAGIC = b"\xA5\x5A"
      RX_FIELDS = ["rx_time_us", "rx_time_iso", "is_test", "run_id", "seq", "size", "msg_id", "host", "payload_hex"]


      class TestTrafficRX(gr.basic_block):
          def __init__(self, log_dir="~/link_tests", verbose=1, print_every=10):
              gr.basic_block.__init__(self, name="Test Traffic RX", in_sig=None, out_sig=None)
              self.log_dir = str(log_dir)
              self.verbose = int(verbose)
              self.print_every = max(1, int(print_every))
              self._host = socket.gethostname()
              self._f = None
              self._w = None
              self._path = None
              self._runs = {}            # run_id -> {"seqs": set, "max": int, "dups": int}
              self._n_other = 0

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self._handle)

          # ---------------------------------------------------------------- file
          def start(self):
              self._open()
              return True

          def stop(self):
              self._summary()
              if self._f:
                  self._f.close()
                  self._f = None
              return True

          def _open(self):
              if self._f:
                  return
              d = os.path.expanduser(self.log_dir)
              os.makedirs(d, exist_ok=True)
              self._path = os.path.join(d, f"rx_{datetime.datetime.now():%Y%m%d_%H%M%S}.csv")
              self._f = open(self._path, "w", newline="")
              self._w = csv.writer(self._f)
              self._w.writerow(RX_FIELDS)
              self._f.flush()
              print(f"[TEST RX] logging received frames to {self._path}", flush=True)

          # ---------------------------------------------------------------- messages
          def _handle(self, msg):
              t_us = time.time_ns() // 1000
              meta = pmt.PMT_NIL
              try:
                  data = msg
                  if pmt.is_pair(msg):
                      meta, data = pmt.car(msg), pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      payload = bytes(pmt.u8vector_elements(data))
                  elif pmt.is_symbol(data):
                      payload = pmt.symbol_to_string(data).encode("utf-8")
                  else:
                      payload = str(pmt.to_python(data)).encode("utf-8")
              except Exception as e:
                  print(f"[TEST RX] could not parse message: {e!r}", flush=True)
                  return

              msg_id = -1
              try:
                  if pmt.is_dict(meta):
                      v = pmt.dict_ref(meta, pmt.intern("msg_id"), pmt.PMT_NIL)
                      if pmt.is_integer(v):
                          msg_id = pmt.to_long(v)
              except Exception:
                  pass

              is_test = len(payload) >= 8 and payload[:2] == MAGIC
              run_id = int.from_bytes(payload[2:4], "big") if is_test else -1
              seq = int.from_bytes(payload[4:8], "big") if is_test else -1

              self._open()
              self._w.writerow([t_us,
                                datetime.datetime.fromtimestamp(t_us / 1e6).isoformat(timespec="milliseconds"),
                                int(is_test), run_id, seq, len(payload), msg_id, self._host, payload.hex()])
              self._f.flush()

              if not is_test:
                  self._n_other += 1
                  return
              st = self._runs.setdefault(run_id, {"seqs": set(), "max": -1, "dups": 0})
              if seq in st["seqs"]:
                  st["dups"] += 1
              st["seqs"].add(seq)
              st["max"] = max(st["max"], seq)
              n = len(st["seqs"])
              if self.verbose and (n == 1 or n % self.print_every == 0):
                  expected = st["max"] + 1
                  print(f"[TEST RX] run {run_id:04x}: {n} received, last seq {seq}, {expected - n} missing so far "
                        f"({100.0 * n / expected:.1f}% of seq 0..{st['max']})", flush=True)

          def _summary(self):
              for run_id, st in self._runs.items():
                  n, expected = len(st["seqs"]), st["max"] + 1
                  print(f"[TEST RX] run {run_id:04x} total: {n} received of seq 0..{st['max']} "
                        f"({100.0 * n / max(expected, 1):.1f}%), {st['dups']} duplicates", flush=True)
              if self._n_other:
                  print(f"[TEST RX] {self._n_other} non-test frames logged", flush=True)
              if self._path:
                  print(f"[TEST RX] log: {self._path}", flush=True)
    log_dir: '"~/link_tests"'
    print_every: '10'
    verbose: '1'
  states: {state: disabled}
- name: epy_block_corr
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Training-word correlator (drop-in for digital_corr_est_cc)
      - Input : complex stream at 2 samples/symbol (symbol sync output)
      - Output: the same stream delayed by a fixed EVEN number of samples (so tags can be placed in the past
        without shifting the symbol / midpoint sample phase)
      - Slides the reference (TRAIN_REF) over the stream and computes the NORMALIZED correlation
            rho = |sum(conj(ref) * x)|^2 / (E_ref * E_window)      (0..1, independent of signal amplitude)
        Where rho has a local maximum above thr it adds a 'corr_est' tag (and 'corr_start') on the
        first training symbol, shifted by mark_delay samples. Random data gives rho ~ 0.1-0.25; a real
        training word gives ~0.8-1.0, so thr ~ 0.6-0.7 is a good start. The tag value is rho.
      - Pure numpy, bounds-checked: no use of GNU Radio's corr_est_cc.
      """
      import numpy as np
      import pmt
      from gnuradio import gr


      def _cdp_register(name, blk):
          """Shared registry (one per flowgraph process) read by the Telemetry block."""
          import sys as _sys, types as _types
          reg = _sys.modules.get("cdp_registry")
          if reg is None:
              reg = _types.ModuleType("cdp_registry")
              reg.blocks = {}
              _sys.modules["cdp_registry"] = reg
          reg.blocks[name] = blk


      class TrainCorr(gr.sync_block):
          def __init__(self, ref=None, thr=0.7, mark_delay=0, verbose=1):
              gr.sync_block.__init__(
                  self,
                  name="Training-word Correlator",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
              if ref is None:
                  ref = [1.0]
              self._ref = np.asarray(ref, dtype=np.complex64)
              self._L = len(self._ref)
              self._E = float(np.sum(np.abs(self._ref) ** 2))
              self.thr = float(thr)
              self.mark_delay = max(0, int(mark_delay))
              self.verbose = int(verbose)
              # Output delay: >= L + 3 so every peak is examined exactly once, and a MULTIPLE OF 2 (samples per
              # symbol) so the symbol-timed samples stay on even stream indices -- the linear equalizer takes
              # the first sample of every 2-sample block, so an odd delay would make it sample the midpoints.
              self._D = self._L + 8
              self._D += self._D % 2
              self.set_history(self._D + 1)
              self._next_p = 0               # first absolute input index not yet examined
              self._last_p = -10**12         # last tagged absolute input index
              self._seen = 0                 # samples since last status line
              self._best = 0.0               # strongest normalized correlation since last status line
              self._found = 0
              self._rhos = []
              self._last_work = 0.0
              self._best_tel = 0.0

          def start(self):
              _cdp_register("corr", self)
              return True

          def telemetry(self):
              import time as _time
              r, self._rhos = self._rhos[-200:], []
              b, self._best_tel = self._best_tel, 0.0
              return {"found": self._found, "rho_med": float(np.median(r)) if r else None,
                      "rho_min": float(min(r)) if r else None, "best_rho": b, "thr": self.thr,
                      "last_work_age_s": (_time.monotonic() - self._last_work) if self._last_work else None}

          def work(self, input_items, output_items):
              import time as _time
              self._last_work = _time.monotonic()
              x = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out[:] = x[:n_out]             # in[i] <-> absolute input index a-D+i  ==  output index a+i

              a = self.nitems_written(0)
              base = a - self._D             # absolute input index of x[0]
              if len(x) < self._L + 5:
                  return n_out
              c = np.correlate(x, self._ref, "valid")                  # window starting at x[n]
              w = np.convolve(np.abs(x).astype(np.float64) ** 2, np.ones(self._L), "valid")
              m = (np.abs(c).astype(np.float64) ** 2) / (self._E * w + 1e-12)    # normalized, 0..1
              self._best = max(self._best, float(m.max()))
              self._best_tel = max(self._best_tel, float(m.max()))
              self._seen += n_out

              n0 = max(self._next_p - base, 2, -base)       # first window start to examine (p >= 0)
              n1 = len(m) - 3                               # last start with 2 neighbours on the right
              if n1 >= n0:
                  seg = m[n0 - 2 : n1 + 3]
                  mid = seg[2:-2]
                  thr_abs = self.thr
                  cond = (
                      (mid > thr_abs)
                      & (mid > seg[0:-4]) & (mid > seg[1:-3])
                      & (mid >= seg[3:-1]) & (mid >= seg[4:])
                  )
                  for j in np.flatnonzero(cond):
                      p = base + n0 + int(j)
                      if p - self._last_p < self._L:
                          continue
                      self._last_p = p
                      ratio = float(mid[j])
                      self._found += 1
                      self._rhos.append(ratio)
                      off = int(p + self._D + self.mark_delay)    # output index; always >= a
                      val = pmt.from_double(ratio)
                      self.add_item_tag(0, off, pmt.intern("corr_start"), val)
                      self.add_item_tag(0, off, pmt.intern("corr_est"), val)
                      self._best = 0.0
                      self._seen = 0
                      if self.verbose:
                          print(f"[CORR] train word found: correlation = {ratio:.2f} (thr {self.thr:.2f})", flush=True)
                  self._next_p = base + n1 + 1

              if self.verbose and self._seen > 400000:
                  if self._best > 0.35:
                      print(f"[CORR] no tag; strongest correlation in last window = {self._best:.2f} (thr {self.thr:.2f})", flush=True)
                  self._best = 0.0
                  self._seen = 0
              return n_out
    comment: Python replacement for digital_corr_est_cc (avoids its out-of-range read).
    mark_delay: train_delay
    ref: TRAIN_REF
    thr: corr_thr
    verbose: '1'
  states: {}
- name: epy_csma
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: CSMA/CA MAC with TX mute  (carrier sense + slotted random backoff, single frequency)

      Wiring
        RX  : Pluto Source  -> in0 (this block) -> out0 -> Power Squelch -> ... (rest of the RX chain)
        TX  : Packet Framer TX pdu_out -> pdu_in (this block) ;  pdu_out -> PDU to Tagged Stream -> modulator -> Pluto Sink
        ctrl: optional messages "fail"/"collision" (double the contention window), "ok" (reset it), "flush" (empty the queue)
        tx_start (v6.8): when a frame is released to the air, its "arq_tag" (from the PDU metadata) is published here.
              Connect it to the ARQ block's mac_in, so the ARQ starts its retransmission timer when the frame is really
              sent, not while it still waits here. Frames with metadata "prio" (ARQ ACKs and retransmissions) are
              queued ahead of normal frames.

      TX mute (tx_mute = 1)
        On one frequency the Pluto's own transmitter, powered but idle, leaks its carrier (and the noise around it)
        into its own receiver and raises the noise floor. This block keeps the TX attenuation at mute_att_db
        (89.75 dB = practically off) while idle and sets it to tx_att_db only around its own bursts:
            backoff done -> receiver off -> TX attenuation := tx_att_db -> (write confirmed) -> frame released
            -> RX-off window ends -> TX attenuation := mute_att_db -> (write confirmed) -> receiver on
        The attenuation is written through libiio (the C library GNU Radio's Pluto blocks use, via ctypes; falls back
        to the python 'iio' module) from a worker thread, so the stream never waits on the network. If neither is
        available, or the radio can't be opened at iio_uri, muting is switched off and the block works as v6.2.
        tx_att_db and tx_mute can be changed while running (slider / check box). The attenuation is re-written once a
        second, so a value written by the Pluto Sink's own slider callback is overridden within 1 s.
        With the mute on, the leak appears in our own receiver while we send, so our own echo is only accepted when it
        is echo_margin_db above the noise floor, and the RX-off window never uses less than tx_delay_s.
        If the write is not confirmed within unmute_timeout_s, the frame goes anyway (counted as "late").

      Carrier sense (spike-proof)
        Every nfft samples: FFT, MEDIAN power of the bins inside +/- cs_bw_hz/2 (bins within dc_exclude_hz of 0 Hz left
        out), smoothed over sense_s, compared with a tracked noise floor:
            busy  when  cs > floor + cs_margin_db ;   idle again when  cs < floor + cs_margin_db - cs_hyst_db
        Floor = floor_percentile of cs over floor_window_s (own transmissions excluded); falls at once, rises at most
        floor_rise_db_s dB/s.

      Access (CSMA/CA, as in 802.11 DCF without ACKs)
        Before every frame: backoff of 0 .. cw-1 slots. Slot boundaries: quiet start + difs_s, + slot_s, ... Each
        boundary reached while idle uses up one slot; the frame goes at the boundary where the count reaches zero.
        Busy freezes the count; after it, DIFS again. "fail" on ctrl doubles cw up to cw_max, "ok" resets it.

      Own transmission (half duplex): receiver off from the release decision until
            release + tx_delay + airtime + gate_guard_s     (+ the time the mute write takes, if muting)
        tx_delay = measured echo delay (median, once 3 bursts were seen, if auto_delay = 1), else tx_delay_s.
        gate_mode = 0 (no mute only): wait until the own echo has ended instead.

      All timing runs on the RX sample clock. The stats line also shows how many samples per second really arrive
      (below ~99 % the PC is not keeping up) and the CPU share of this block.
      Read-out for QT widgets (Function Probe): cs_db(), threshold_db(), floor_db(), is_busy(), is_tx(), queue_len(), is_muted()
      """
      import collections
      import os
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      def _cdp_register(name, blk):
          """Shared registry (one per flowgraph process) read by the Telemetry block."""
          import sys as _sys, types as _types
          reg = _sys.modules.get("cdp_registry")
          if reg is None:
              reg = _types.ModuleType("cdp_registry")
              reg.blocks = {}
              _sys.modules["cdp_registry"] = reg
          reg.blocks[name] = blk


      class TxMuter:
          """Writes the Pluto TX attenuation (ad9361-phy, output voltage0, hardwaregain) from a worker thread."""

          def __init__(self, uri, verbose=1):
              self.uri = str(uri)
              self.verbose = int(verbose)
              self.ok = False
              self.failed = False
              self.reason = "connecting"
              self.backend = ""
              self.errors = 0
              self.writes = 0
              self.write_ms = collections.deque(maxlen=200)
              self._cv = threading.Condition()
              self._want = None
              self._seq = 0
              self._done_seq = 0
              self._stop = False
              self._last_write = 0.0
              self._write = None
              self._close = None
              self._thr = None

          # ---- called from the GNU Radio thread
          def start(self):
              self._thr = threading.Thread(target=self._run, name="tx-mute", daemon=True)
              self._thr.start()

          def request(self, att_db):
              with self._cv:
                  self._want = float(att_db)
                  self._seq += 1
                  self._cv.notify()
                  return self._seq

          def done(self, seq):
              return self._done_seq >= seq

          def stop(self, restore_att=None):
              with self._cv:
                  self._stop = True
                  self._cv.notify()
              if self._thr is not None:
                  self._thr.join(timeout=2.0)
              if self.ok and restore_att is not None:
                  try:
                      self._write(float(restore_att))
                  except Exception:
                      pass
              if self._close:
                  try:
                      self._close()
                  except Exception:
                      pass

          # ---- worker thread
          def _open(self):
              errs = []
              try:
                  import ctypes
                  import ctypes.util
                  name = ctypes.util.find_library("iio") or "libiio.so.0"
                  lib = ctypes.CDLL(name)
                  vp, cp = ctypes.c_void_p, ctypes.c_char_p
                  lib.iio_create_context_from_uri.restype = vp
                  lib.iio_create_context_from_uri.argtypes = [cp]
                  lib.iio_context_find_device.restype = vp
                  lib.iio_context_find_device.argtypes = [vp, cp]
                  lib.iio_device_find_channel.restype = vp
                  lib.iio_device_find_channel.argtypes = [vp, cp, ctypes.c_bool]
                  lib.iio_channel_attr_write.restype = ctypes.c_ssize_t
                  lib.iio_channel_attr_write.argtypes = [vp, cp, cp]
                  lib.iio_context_set_timeout.restype = ctypes.c_int
                  lib.iio_context_set_timeout.argtypes = [vp, ctypes.c_uint]
                  lib.iio_context_destroy.restype = None
                  lib.iio_context_destroy.argtypes = [vp]
                  ctx = lib.iio_create_context_from_uri(self.uri.encode())
                  if not ctx:
                      raise RuntimeError(f"cannot open {self.uri}")
                  lib.iio_context_set_timeout(ctx, 1000)
                  dev = lib.iio_context_find_device(ctx, b"ad9361-phy")
                  chn = lib.iio_device_find_channel(dev, b"voltage0", True) if dev else None
                  if not chn:
                      lib.iio_context_destroy(ctx)
                      raise RuntimeError("ad9361-phy output voltage0 not found")

                  def write(att):
                      r = lib.iio_channel_attr_write(chn, b"hardwaregain", f"{-att:.2f}".encode())
                      if r < 0:
                          raise OSError(-r, os.strerror(-r))

                  self._write, self._close = write, (lambda: lib.iio_context_destroy(ctx))
                  self.backend = f"libiio C library ({name})"
                  return
              except Exception as e:
                  errs.append(f"libiio C library: {e}")
              try:
                  import iio
                  ctx = iio.Context(self.uri)
                  dev = ctx.find_device("ad9361-phy")
                  chn = dev.find_channel("voltage0", True) if dev else None
                  if chn is None:
                      raise RuntimeError("ad9361-phy output voltage0 not found")
                  attr = chn.attrs["hardwaregain"]

                  def write(att):
                      attr.value = f"{-att:.2f}"

                  self._write, self._close = write, None
                  self._ctx_keepalive = ctx
                  self.backend = "python iio module"
                  return
              except Exception as e:
                  errs.append(f"python iio module: {e}")
              raise RuntimeError("; ".join(errs))

          def _run(self):
              try:
                  self._open()
              except Exception as e:
                  self.failed, self.reason = True, str(e)
                  print(f"[CSMA] TX mute OFF: could not control the radio's TX attenuation ({e}). Install libiio "
                        f"(Fedora: sudo dnf install libiio python3-libiio) or check iio_uri. Running without mute.", flush=True)
                  return
              self.ok, self.reason = True, "ok"
              if self.verbose:
                  print(f"[CSMA] TX mute ready ({self.backend}, {self.uri})", flush=True)
              while True:
                  with self._cv:
                      while (not self._stop and self._seq == self._done_seq
                             and time.monotonic() - self._last_write < 1.0):
                          self._cv.wait(timeout=0.25)
                      if self._stop:
                          return
                      seq, att = self._seq, self._want
                  if att is not None:
                      t = time.perf_counter()
                      try:
                          self._write(att)
                          self.writes += 1
                          self.write_ms.append(1e3 * (time.perf_counter() - t))
                      except Exception as e:
                          self.errors += 1
                          if self.errors <= 3:
                              print(f"[CSMA] TX attenuation write failed: {e}", flush=True)
                  self._last_write = time.monotonic()
                  with self._cv:
                      self._done_seq = max(self._done_seq, seq)


      class CsmaMac(gr.sync_block):
          def __init__(self, samp_rate=1.5e6, samples_per_byte=32, slot_s=0.015, difs_s=0.020,
                       cw_min=8, cw_max=128, cs_margin_db=6.0, cs_hyst_db=2.0, cs_bw_hz=400e3,
                       dc_exclude_hz=10e3, nfft=256, sense_s=0.001, floor_window_s=2.0,
                       floor_percentile=10.0, floor_rise_db_s=1.0, echo_timeout_s=0.100, tail_s=0.002,
                       blank_rx=1, max_queue=64, max_defer_s=0.0, verbose=1, stats_every_s=10.0,
                       gate_mode=1, tx_delay_s=0.012, auto_delay=1, gate_guard_s=0.005,
                       tx_mute=1, iio_uri="ip:192.168.1.10", tx_att_db=20.0, mute_att_db=89.75,
                       unmute_timeout_s=0.1, echo_margin_db=25.0):
              gr.sync_block.__init__(self, name="CSMA/CA MAC + TX mute", in_sig=[np.complex64], out_sig=[np.complex64])
              self.samp_rate = float(samp_rate)
              self.samples_per_byte = float(samples_per_byte)
              self.slot_s = float(slot_s)
              self.difs_s = float(difs_s)
              self.cw_min = max(1, int(cw_min))
              self.cw_max = max(self.cw_min, int(cw_max))
              self.cs_margin_db = float(cs_margin_db)
              self.cs_hyst_db = float(cs_hyst_db)
              self.floor_percentile = float(floor_percentile)
              self.floor_rise_db_s = float(floor_rise_db_s)
              self.echo_timeout_s = float(echo_timeout_s)
              self.tail_s = float(tail_s)
              self.blank_rx = int(blank_rx)
              self.gate_mode = int(gate_mode)
              self.tx_delay_s = float(tx_delay_s)
              self.auto_delay = int(auto_delay)
              self.gate_guard_s = float(gate_guard_s)
              self._sense_s = float(sense_s)
              self.max_queue = max(1, int(max_queue))
              self.max_defer_s = float(max_defer_s)
              self.verbose = int(verbose)
              self.stats_every_s = float(stats_every_s)
              # TX mute (tx_mute and tx_att_db are plain attributes: GRC sliders / check boxes update them live)
              self.tx_mute = int(tx_mute)
              self.iio_uri = str(iio_uri)
              self.tx_att_db = float(tx_att_db)
              self.mute_att_db = float(mute_att_db)
              self.unmute_timeout_s = float(unmute_timeout_s)
              self.echo_margin_db = float(echo_margin_db)
              self._muter = None
              self._req_att = None
              self._mute_seq = 0
              self._seen = (None, None)
              self._unmute_delays = collections.deque(maxlen=200)

              # ---- carrier-sense front end
              self._nfft = int(nfft)
              self._dt = self._nfft / self.samp_rate
              f = np.fft.fftfreq(self._nfft, 1.0 / self.samp_rate)
              sel = (np.abs(f) <= float(cs_bw_hz) / 2) & (np.abs(f) >= float(dc_exclude_hz))
              self._bins = np.flatnonzero(sel)
              if self._bins.size < 8:
                  raise ValueError("cs_bw_hz / dc_exclude_hz / nfft leave fewer than 8 bins to sense")
              self._win = np.hanning(self._nfft).astype(np.float32)
              self._norm = 1.0 / (np.log(2.0) * self._nfft * float(np.mean(self._win ** 2)))
              self._smooth = collections.deque(maxlen=max(1, int(round(float(sense_s) / self._dt))))
              self._carry = np.zeros(0, np.complex64)
              self._cs_db = -200.0
              n_hist = max(64, int(float(floor_window_s) / self._dt))
              self._hist = collections.deque(maxlen=n_hist)
              self._floor_db = None
              self._floor_next = 0.0
              self._busy = True

              # ---- MAC state
              self._lock = threading.Lock()
              self._queue = collections.deque()
              self._cw = self.cw_min
              self._backoff = None
              self._idle_run = 0.0
              self._rng = np.random.default_rng()
              self._n_abs = 0
              self._t = 0.0
              self._self_tx = False
              self._tx = {}

              # ---- statistics
              self._st = collections.Counter()
              self._echo_delays = collections.deque(maxlen=200)
              self._access_delays = collections.deque(maxlen=200)
              self._busy_time = 0.0
              self._stat_t0 = 0.0
              self._warned_no_echo = False
              self._wall0 = None
              self._n_wall0 = 0
              self._cpu = 0.0
              self._windows = 0
              self._last_work = 0.0                 # telemetry: PC time of the last work() call
              self._busy_total = 0.0
              self._tel_prev = None
              self._cpu_total = 0.0

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self._on_pdu)
              self.message_port_register_in(pmt.intern("ctrl"))
              self.set_msg_handler(pmt.intern("ctrl"), self._on_ctrl)
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("tx_start"))

          # ------------------------------------------------------------------ start / stop (radio access only here,
          # never in __init__: GRC builds the block once just to read its ports)
          def start(self):
              self._muter = TxMuter(self.iio_uri, self.verbose)
              self._muter.start()
              _cdp_register("csma", self)
              return True

          def telemetry(self):
              """Snapshot for the Telemetry block (called from its thread, read-only)."""
              now = time.monotonic()
              prev, cur = self._tel_prev, (now, self._n_abs, self._t, self._busy_total, self._cpu_total)
              self._tel_prev = cur
              rate = busy = cpu = None
              if prev is not None and cur[0] > prev[0]:
                  rate = (cur[1] - prev[1]) / (cur[0] - prev[0])
                  dts = cur[2] - prev[2]
                  busy = (cur[3] - prev[3]) / dts if dts > 0 else None
                  cpu = (cur[4] - prev[4]) / (cur[0] - prev[0])
              with self._lock:
                  q = len(self._queue)
                  oldest = (self._t - min(e[1] for e in list(self._queue))) if q else 0.0
              ad, ed = list(self._access_delays), list(self._echo_delays)
              m = self._muter
              tx = self._tx
              phase_t = tx.get("t_dec", tx.get("t0")) if self._self_tx else None
              return {
                  "floor_db": self._floor_db, "cs_db": float(self._cs_db), "margin_db": self.cs_margin_db,
                  "busy": bool(self._busy), "busy_frac": busy, "self_tx": bool(self._self_tx), "phase": tx.get("phase"),
                  "phase_age_s": (self._t - phase_t) if phase_t is not None else 0.0,
                  "tx": self._st["tx"], "deferrals": self._st["deferrals"], "dropped": self._st["dropped"], "prio": self._st["prio"],
                  "forced": self._st["forced"], "no_echo": self._st["no_echo"], "late_unmute": self._st["late_unmute"],
                  "queue": q, "oldest_queued_s": oldest, "cw": self._cw,
                  "access_med_ms": 1e3 * float(np.median(ad)) if ad else None,
                  "access_p95_ms": 1e3 * float(np.percentile(ad, 95)) if ad else None,
                  "echo_med_ms": 1e3 * float(np.median(ed)) if ed else None,
                  "echo_max_ms": 1e3 * float(max(ed)) if ed else None, "tx_delay_ms": 1e3 * self._tx_delay(),
                  "slot_ms": 1e3 * self.slot_s, "difs_ms": 1e3 * self.difs_s, "guard_ms": 1e3 * self.gate_guard_s,
                  "rx_rate": rate, "rx_rate_pct": 100.0 * rate / self.samp_rate if rate else None, "cpu_frac": cpu,
                  "last_work_age_s": (now - self._last_work) if self._last_work else None,
                  "mute": {"enabled": bool(self.tx_mute), "ok": bool(m and m.ok), "failed": bool(m and m.failed),
                           "reason": m.reason if m else "not started", "errors": m.errors if m else 0,
                           "writes": m.writes if m else 0,
                           "write_med_ms": float(np.median(list(m.write_ms))) if m and m.write_ms else None,
                           "write_max_ms": float(max(m.write_ms)) if m and m.write_ms else None,
                           "tx_att_db": self.tx_att_db, "idle_att_db": self.mute_att_db},
              }

          def stop(self):
              if self._muter is not None:
                  self._muter.stop(restore_att=self.tx_att_db)
              return True

          # ------------------------------------------------------------------ read-outs (Function Probe)
          def cs_db(self):
              return float(self._cs_db)

          def floor_db(self):
              return float(self._floor_db) if self._floor_db is not None else -200.0

          def threshold_db(self):
              return self.floor_db() + self.cs_margin_db

          def is_busy(self):
              return int(self._busy or self._self_tx)

          def is_tx(self):
              return int(self._self_tx)

          def queue_len(self):
              return len(self._queue)

          def is_muted(self):
              return int(self._mute_on() and self._req_att == self.mute_att_db)

          # ------------------------------------------------------------------ TX mute helpers
          def _mute_on(self):
              return bool(self.tx_mute) and self._muter is not None and self._muter.ok

          def _desired_att(self):
              if self._muter is None or not self._muter.ok:
                  return None
              if not self.tx_mute:
                  return self.tx_att_db
              if self._self_tx and self._tx.get("phase") in ("unmute", "air"):
                  return self.tx_att_db
              return self.mute_att_db

          def _sync_mute(self, force=False):
              att = self._desired_att()
              if att is not None and (force or att != self._req_att):
                  self._mute_seq = self._muter.request(att)
                  self._req_att = att
              return self._mute_seq

          # ------------------------------------------------------------------ messages
          @staticmethod
          def _meta(msg, key):
              try:
                  m = pmt.car(msg)
                  if not pmt.is_dict(m):
                      return None
                  v = pmt.dict_ref(m, pmt.intern(key), pmt.PMT_NIL)
                  return None if pmt.is_null(v) else v
              except Exception:
                  return None

          def _on_pdu(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  print("[CSMA] pdu_in expects a PDU (meta . u8vector) from the framer; message ignored", flush=True)
                  return
              prio = self._meta(msg, "prio") is not None
              with self._lock:
                  if len(self._queue) >= self.max_queue:
                      self._queue.popleft()
                      self._st["dropped"] += 1
                      print(f"[CSMA] queue full ({self.max_queue}): oldest frame dropped", flush=True)
                  if prio:                                  # ACKs and resends go ahead of normal frames (FIFO among them)
                      i = 0
                      while i < len(self._queue) and self._meta(self._queue[i][0], "prio") is not None:
                          i += 1
                      self._queue.insert(i, (msg, self._t))
                      self._st["prio"] += 1
                  else:
                      self._queue.append((msg, self._t))

          def _on_ctrl(self, msg):
              try:
                  txt = str(pmt.to_python(pmt.car(msg) if pmt.is_pair(msg) else msg)).lower()
              except Exception:
                  txt = ""
              if "fail" in txt or "collision" in txt or "nack" in txt:
                  self._cw = min(self.cw_max, self._cw * 2)
              elif "ok" in txt or "success" in txt or "ack" in txt:
                  self._cw = self.cw_min
              elif "flush" in txt:
                  with self._lock:
                      self._queue.clear()

          # ------------------------------------------------------------------ carrier sense helpers
          def _update_floor(self):
              if len(self._hist) < self._hist.maxlen // 4:
                  return
              raw = float(np.percentile(np.fromiter(self._hist, float, len(self._hist)), self.floor_percentile))
              if self._floor_db is None or raw <= self._floor_db:
                  self._floor_db = raw
              else:
                  self._floor_db = min(raw, self._floor_db + self.floor_rise_db_s * 0.05)

          # ------------------------------------------------------------------ own transmission
          def _release(self):
              """Backoff done: receiver off; unmute the TX first if muting, then send."""
              with self._lock:
                  if not self._queue:
                      return
                  msg, t_enq = self._queue.popleft()
              nbytes = pmt.length(pmt.cdr(msg))
              airtime = nbytes * self.samples_per_byte / self.samp_rate
              self._backoff, self._idle_run = None, 0.0
              self._self_tx = True
              if self._mute_on():
                  self._tx = {"phase": "unmute", "msg": msg, "nbytes": nbytes, "air": airtime, "t_enq": t_enq,
                              "t_dec": self._t, "mute": True}
                  self._tx["seq"] = self._sync_mute()
              else:
                  self._tx = {"mute": False}
                  self._publish(msg, nbytes, airtime, t_enq)

          def _publish(self, msg, nbytes, airtime, t_enq):
              self.message_port_pub(pmt.intern("pdu_out"), msg)
              tag = self._meta(msg, "arq_tag")
              if tag is not None:
                  self.message_port_pub(pmt.intern("tx_start"), tag)
              delay = self._tx_delay()
              self._tx.update({"phase": "air", "t0": self._t, "air": airtime, "echo_t": None, "low_since": None,
                               "hard_end": self._t + self.echo_timeout_s + airtime + self.tail_s + 0.02,
                               "win_end": self._t + delay + airtime + self.gate_guard_s})
              self._tx.pop("msg", None)
              self._st["tx"] += 1
              self._access_delays.append(self._t - t_enq)
              if self.verbose >= 2:
                  print(f"[CSMA] TX {nbytes} B frame ({airtime * 1e3:.1f} ms) after {1e3 * (self._t - t_enq):.1f} ms "
                        f"in queue, cw {self._cw}", flush=True)

          def _tx_delay(self):
              if self.auto_delay and len(self._echo_delays) >= 3:
                  d = float(np.median(self._echo_delays))
                  # with the mute on, the leak can fake an early echo: never go below tx_delay_s then
                  return max(d, self.tx_delay_s) if self._mute_on() else d
              return self.tx_delay_s

          def _end_self_tx(self, reason):
              self._self_tx = False
              if reason == "echo_end":
                  self._idle_run = self.tail_s
              elif reason == "window":
                  # our burst ended at about win_end - guard; the other node noticed it about sense_s later. Count idle
                  # time from there (including any wait for the mute write) so both slot grids line up.
                  # A long wait (> 5 ms) is not counted as idle: the other node may have started meanwhile, unseen, so
                  # start a fresh DIFS instead.
                  extra = max(0.0, self._t - self._tx.get("win_end", self._t))
                  self._idle_run = self.gate_guard_s - self._sense_s + extra if extra <= 0.005 else 0.0
              else:
                  self._idle_run = 0.0
              if reason == "timeout" and self._tx.get("echo_t") is None:
                  self._st["no_echo"] += 1
                  if not self._warned_no_echo:
                      self._warned_no_echo = True
                      print("[CSMA] own burst not seen on our receiver: RX blanking falls back to the timer "
                            "(echo_timeout_s + airtime). Check the TX, or raise echo_timeout_s.", flush=True)
              self._tx = {}

          # ------------------------------------------------------------------ one sense step (nfft samples)
          def _step(self, cs_db):
              dt = self._dt
              thr_on = (self._floor_db if self._floor_db is not None else 1e9) + self.cs_margin_db
              loud = cs_db > thr_on

              if self._self_tx:
                  tx = self._tx
                  phase = tx.get("phase")
                  if phase == "unmute":                            # waiting for the TX attenuation write
                      if self._muter.done(tx["seq"]) or self._t - tx["t_dec"] >= self.unmute_timeout_s:
                          if not self._muter.done(tx["seq"]):
                              self._st["late_unmute"] += 1
                          self._unmute_delays.append(self._t - tx["t_dec"])
                          self._publish(tx["msg"], tx["nbytes"], tx["air"], tx["t_enq"])
                      return
                  if phase == "mute":                              # waiting for the mute write before listening again
                      if self._muter.done(tx["seq"]) or self._t - tx["win_end"] >= self.unmute_timeout_s:
                          self._end_self_tx("window")
                      return
                  if self.gate_mode == 1 or tx.get("mute"):        # fixed receive-off window
                      echo_thr = thr_on if not tx.get("mute") else \
                          (self._floor_db if self._floor_db is not None else 1e9) + max(self.cs_margin_db, self.echo_margin_db)
                      if (tx["echo_t"] is None and cs_db > echo_thr and self._t < tx["win_end"]
                              and self._t - tx["t0"] >= 0.002):    # < 2 ms is not our burst (leak / noise)
                          tx["echo_t"] = self._t
                          self._echo_delays.append(self._t - tx["t0"])
                      if self._t >= tx["win_end"]:
                          if tx["echo_t"] is None:
                              self._st["no_echo"] += 1
                          if self._mute_on():
                              tx["phase"] = "mute"
                              tx["seq"] = self._sync_mute()
                          else:
                              self._end_self_tx("window")
                      return
                  # gate_mode 0 (no mute): wait until our own echo has ended
                  if tx["echo_t"] is None:
                      if loud:
                          tx["echo_t"] = self._t
                          self._echo_delays.append(self._t - tx["t0"])
                      elif self._t - tx["t0"] > self.echo_timeout_s + tx["air"] + self.tail_s:
                          self._end_self_tx("timeout")
                          return
                  else:
                      if loud:
                          tx["low_since"] = None
                      elif tx["low_since"] is None:
                          tx["low_since"] = self._t
                      elif self._t - tx["low_since"] >= self.tail_s:
                          self._end_self_tx("echo_end")
                          return
                  if self._t >= tx["hard_end"]:
                      self._end_self_tx("timeout")
                  return

              # channel state with hysteresis (busy until the floor is known)
              self._hist.append(cs_db)
              if self._floor_db is None:
                  self._busy = True
              elif self._busy:
                  self._busy = cs_db > thr_on - self.cs_hyst_db
              else:
                  self._busy = loud
              if self._busy:
                  self._busy_time += dt
                  self._busy_total += dt

              with self._lock:
                  pending = len(self._queue)
                  t_head = self._queue[0][1] if pending else None
              if not pending:
                  self._idle_run = 0.0 if self._busy else self._idle_run + dt
                  return

              if self.max_defer_s > 0 and self._t - t_head > self.max_defer_s and self._floor_db is not None:
                  self._st["forced"] += 1
                  self._release()
                  return

              if self._backoff is None:
                  self._backoff = int(self._rng.integers(0, self._cw))

              if self._busy:
                  if self._idle_run > 0.0:
                      self._st["deferrals"] += 1
                  self._idle_run = 0.0
                  return

              p_prev = self._idle_run - self.difs_s
              self._idle_run += dt
              p_now = self._idle_run - self.difs_s
              if p_now < 0:
                  return
              crossings = int(np.floor(p_now / self.slot_s)) - int(np.floor(p_prev / self.slot_s))
              for _ in range(crossings):
                  if self._backoff == 0:
                      self._release()
                      return
                  self._backoff -= 1

          # ------------------------------------------------------------------ stream
          def work(self, input_items, output_items):
              t_cpu = time.perf_counter()
              self._last_work = time.monotonic()
              if self._wall0 is None:
                  self._wall0, self._n_wall0 = time.monotonic(), self._n_abs
              if self._muter is not None:
                  seen = (self.tx_mute, self.tx_att_db)
                  self._sync_mute(force=(seen != self._seen))      # slider / check box changed: write again
                  self._seen = seen
              x = input_items[0]
              out = output_items[0]
              n = len(x)
              out[:] = x

              first_abs = self._n_abs - len(self._carry)
              buf = np.concatenate((self._carry, x)) if len(self._carry) else x
              nb = len(buf) // self._nfft
              blank = []
              if nb:
                  blocks = buf[:nb * self._nfft].reshape(nb, self._nfft) * self._win
                  p = np.abs(np.fft.fft(blocks, axis=1)[:, self._bins]) ** 2
                  med = np.median(p, axis=1) * self._norm
                  for i in range(nb):
                      self._smooth.append(float(med[i]))
                      self._cs_db = 10.0 * np.log10(max(sum(self._smooth) / len(self._smooth), 1e-20))
                      self._t = (first_abs + (i + 1) * self._nfft) / self.samp_rate
                      was_tx = self._self_tx
                      self._step(self._cs_db)
                      if self.blank_rx and (was_tx or self._self_tx):
                          s = first_abs + i * self._nfft
                          blank.append((s, s + self._nfft))
                      if self._t >= self._floor_next:
                          self._floor_next = self._t + 0.05
                          self._update_floor()
              self._carry = buf[nb * self._nfft:].copy()
              self._n_abs += n

              if self.blank_rx and self._self_tx:
                  blank.append((self._n_abs - len(self._carry), self._n_abs))
              x0 = self._n_abs - n
              for s, e in blank:
                  a, b = max(s, x0) - x0, min(e, self._n_abs) - x0
                  if b > a:
                      out[a:b] = 0

              dcpu = time.perf_counter() - t_cpu
              self._cpu += dcpu
              self._cpu_total += dcpu
              if self.verbose and self.stats_every_s > 0 and self._t - self._stat_t0 >= self.stats_every_s:
                  self._print_stats()
              return n

          def _print_stats(self):
              span = max(1e-9, self._t - self._stat_t0)
              ed = list(self._echo_delays)
              ad = list(self._access_delays)
              echo = (f"own echo after {1e3 * np.median(ed):.1f} ms (max {1e3 * max(ed):.1f}) -> keep slot_s above it"
                      if ed else "own echo not measured yet")
              if self.gate_mode == 1 or self._mute_on():
                  echo += f" | RX off for {1e3 * self._tx_delay():.1f} ms + airtime + {1e3 * self.gate_guard_s:.1f} ms"
              floor = f"{self._floor_db:.1f}" if self._floor_db is not None else "learning"
              print(f"[CSMA] floor {floor} dB, threshold +{self.cs_margin_db:g} dB, now {self._cs_db:.1f} dB, "
                    f"busy {100 * self._busy_time / span:.1f} % | tx {self._st['tx']}, deferrals {self._st['deferrals']}, "
                    f"queue {len(self._queue)}, cw {self._cw}, dropped {self._st['dropped']}, forced {self._st['forced']}, "
                    f"no-echo {self._st['no_echo']} | access delay median "
                    f"{(1e3 * np.median(ad)) if ad else 0:.0f} ms | {echo}", flush=True)
              m = self._muter
              if m is None or m.failed:
                  mute = f"TX mute OFF ({m.reason if m else 'not started'})"
              elif not m.ok:
                  mute = "TX mute: connecting to the radio"
              elif not self.tx_mute:
                  mute = f"TX mute switched off: TX always at {self.tx_att_db:g} dB"
              else:
                  wm = list(m.write_ms)
                  ud = list(self._unmute_delays)
                  mute = (f"TX mute on: idle {self.mute_att_db:g} dB, sending {self.tx_att_db:g} dB | attenuation write "
                          f"{np.median(wm) if wm else 0:.1f} ms median (max {max(wm) if wm else 0:.1f}), unmute wait "
                          f"{1e3 * np.median(ud) if ud else 0:.1f} ms median, late {self._st['late_unmute']}, "
                          f"write errors {m.errors}")
              wall = max(1e-9, time.monotonic() - self._wall0)
              rate = (self._n_abs - self._n_wall0) / wall
              share = 100.0 * rate / self.samp_rate
              print(f"[CSMA] {mute} | radio delivers {rate / 1e6:.4f} Msps = {share:.1f} % of samp_rate | this block "
                    f"uses {100.0 * self._cpu / wall:.0f} % of one CPU core", flush=True)
              self._windows += 1
              if self._windows >= 2 and share < 99.0:
                  print(f"[CSMA] WARNING: only {share:.1f} % of the samples arrive. The PC is not keeping up and the radio "
                        f"drops samples, which breaks frames (train word found, CRC fails). Close GUI sinks you do not "
                        f"need, run without the GUI, or lower samp_rate.", flush=True)
              self._wall0, self._n_wall0, self._cpu = time.monotonic(), self._n_abs, 0.0
              self._stat_t0 = self._t
              self._busy_time = 0.0
    auto_delay: '1'
    blank_rx: '1'
    comment: 'v6.8: tx_start -> ARQ mac_in (frame really on air). ARQ ACKs and resends are queued ahead of normal frames.'
    cs_bw_hz: 400e3
    cs_hyst_db: '2.0'
    cs_margin_db: cs_margin
    cw_max: SET_CSMA_CWMAX
    cw_min: SET_CSMA_CWMIN
    dc_exclude_hz: 10e3
    difs_s: SET_CSMA_DIFS
    echo_margin_db: '25.0'
    echo_timeout_s: '0.100'
    floor_percentile: '10.0'
    floor_rise_db_s: '1.0'
    floor_window_s: '2.0'
    gate_guard_s: SET_CSMA_GUARD
    gate_mode: '1'
    iio_uri: ADDR
    max_defer_s: '0.0'
    max_queue: '64'
    mute_att_db: '89.75'
    nfft: '256'
    samp_rate: samp_rate
    samples_per_byte: 8*sps
    sense_s: '0.001'
    slot_s: SET_CSMA_SLOT
    stats_every_s: '10.0'
    tail_s: '0.002'
    tx_att_db: CH_GAIN
    tx_delay_s: SET_CSMA_TXDELAY
    tx_mute: TX_MUTE
    unmute_timeout_s: '0.1'
    verbose: '1'
  states: {}
- name: epy_noise
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Noise-floor tracker -> automatic squelch threshold
      - Sink block: connect it to the SDR source output (BEFORE any squelch/AGC).
      - Splits the stream into short slices (default ~1 ms), keeps the mean power of each slice for the
        last `window_s` seconds, and takes a low percentile of them as the noise floor (bursts only occupy
        the top of the distribution, so they are ignored as long as the channel is idle > `percentile` % of the time).
      - level() returns the squelch threshold in dB:  noise floor (dB) + margin_db, clamped to
        [thr_min, thr_max]. The estimate falls immediately but rises at most `rise_db_s` dB per second, so a
        long burst or a back-to-back transmission cannot drag the threshold up and close the squelch.
      - Use with a "Function Probe" variable named power_threshold:  block id = this block, function = level,
        poll rate ~ 5 Hz. The Pluto/squelch power unit is the same: dB of mean |x|^2.
      """
      import threading
      import time
      from collections import deque

      import numpy as np
      from gnuradio import gr


      def _cdp_register(name, blk):
          """Shared registry (one per flowgraph process) read by the Telemetry block."""
          import sys as _sys, types as _types
          reg = _sys.modules.get("cdp_registry")
          if reg is None:
              reg = _types.ModuleType("cdp_registry")
              reg.blocks = {}
              _sys.modules["cdp_registry"] = reg
          reg.blocks[name] = blk


      class NoiseFloor(gr.sync_block):
          def __init__(self, samp_rate=1.5e6, margin_db=6.0, window_s=1.0, percentile=10.0,
                       rise_db_s=1.0, thr_min=-100.0, thr_max=-20.0, init_db=-40.0, verbose=1):
              gr.sync_block.__init__(self, name="Noise Floor Tracker", in_sig=[np.complex64], out_sig=None)
              self.samp_rate = float(samp_rate)
              self.margin_db = float(margin_db)
              self.window_s = float(window_s)
              self.percentile = float(percentile)
              self.rise_db_s = float(rise_db_s)
              self.thr_min = float(thr_min)
              self.thr_max = float(thr_max)
              self.init_db = float(init_db)
              self.verbose = int(verbose)

              self._slice = max(64, int(self.samp_rate * 1e-3))            # ~1 ms
              n_slices = max(16, int(self.window_s * self.samp_rate / self._slice))
              self._ring = deque(maxlen=n_slices)
              self._min_slices = max(8, n_slices // 4)                       # wait for 1/4 window before trusting
              self._carry = np.zeros(0, np.float32)
              self._lock = threading.Lock()
              self._est_db = None
              self._t_last = None
              self._out = self.init_db
              self._printed = None
              self._last_work = 0.0

          def start(self):
              _cdp_register("noise", self)
              return True

          def telemetry(self):
              now = time.monotonic()
              return {"floor_db": self._est_db, "threshold_db": self._out, "margin_db": self.margin_db,
                      "last_work_age_s": (now - self._last_work) if self._last_work else None}

          def work(self, input_items, output_items):
              self._last_work = time.monotonic()
              x = input_items[0]
              n = len(x)
              if n == 0:
                  return 0
              p = x.real.astype(np.float32) ** 2 + x.imag.astype(np.float32) ** 2
              if self._carry.size:
                  p = np.concatenate((self._carry, p))
              k = len(p) // self._slice
              if k:
                  means = p[: k * self._slice].reshape(k, self._slice).mean(axis=1, dtype=np.float64)
                  with self._lock:
                      self._ring.extend(means)
              self._carry = p[k * self._slice:]
              return n

          def noise_db(self):
              return self._est_db

          def level(self):
              """Called by the Function Probe variable: returns the squelch threshold in dB."""
              with self._lock:
                  arr = np.fromiter(self._ring, dtype=np.float64, count=len(self._ring))
              if arr.size < self._min_slices:
                  return self._out
              raw_db = 10.0 * np.log10(max(float(np.percentile(arr, self.percentile)), 1e-20))
              now = time.monotonic()
              if self._est_db is None:
                  self._est_db = raw_db
              else:
                  dt = max(0.0, now - self._t_last)
                  if raw_db <= self._est_db:
                      self._est_db = raw_db
                  else:
                      self._est_db = min(raw_db, self._est_db + self.rise_db_s * dt)
              self._t_last = now
              self._out = float(min(self.thr_max, max(self.thr_min, self._est_db + self.margin_db)))
              if self.verbose and (self._printed is None or abs(self._out - self._printed) >= 1.0):
                  print(f"[SQL] noise floor {self._est_db:.1f} dB -> squelch threshold {self._out:.1f} dB", flush=True)
                  self._printed = self._out
              return self._out
    init_db: '-40.0'
    margin_db: margin_db
    percentile: '10.0'
    rise_db_s: '1.0'
    samp_rate: samp_rate
    thr_max: '-20.0'
    thr_min: '-100.0'
    verbose: '1'
    window_s: '1.0'
  states: {}
- name: epy_telem
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Telemetry + watchdog (reads the other blocks through a shared registry)

      Port: mac_in (message) - connect the ARQ block's mac_ctrl output here. Besides counting the ARQ's ok/fail
      signals, this connection is what makes GNU Radio run this block at all (unconnected blocks are never started).

      Every period_s it takes a snapshot of every registered block (csma, deframer, arq, udp, noise, corr, txprobe) and of
      the process (CPU, per-thread CPU by GNU Radio thread name, memory, how late this thread wakes up = GIL stalls),
      checks it for problems (stalled receive stream, stuck CSMA state, stalled TX path, stuck ARQ messages, frames
      waiting in the deframer, dropped samples, TX mute errors ...), and
        - appends it to <log_dir>/telemetry_node<ID>.jsonl (one JSON line per snapshot; rotated at 50 MB)
        - sends it as one JSON line to every client of tcp://bind_addr:port (the dashboard of cdp_link_app.py)
        - prints problems as [WATCHDOG] lines.
      When the receive stream, the ARQ thread or a CSMA state stalls, it writes the Python stack of every thread to
      <log_dir>/stacks_node<ID>.txt. "kill -USR1 <pid>" (or the dashboard's "Dump stacks") writes them too, even if
      the process is frozen (faulthandler).

      Commands (one JSON object per line from a client):
        {"cmd": "set", "target": "arq", "key": "max_rto_s", "value": 4}   change a parameter while running
        {"cmd": "stacks"}                                                  dump all Python thread stacks now
        {"cmd": "snapshot"}                                                send a snapshot now
      """
      import collections
      import json
      import os
      import selectors
      import socket
      import sys
      import threading
      import time
      import traceback
      from datetime import datetime

      import pmt
      from gnuradio import gr

      LIVE = {
          "arq": {"mss": int, "window": int, "ack_every": int, "ack_delay_s": float, "init_rto_s": float,
                  "min_rto_s": float, "max_rto_s": float, "max_retries": int},
          "csma": {"slot_s": float, "difs_s": float, "cw_min": int, "cw_max": int, "cs_margin_db": float,
                   "gate_guard_s": float, "tx_delay_s": float, "tx_att_db": float, "tx_mute": int},
          "noise": {"margin_db": float},
          "deframer": {"debug": int},
          "corr": {"thr": float},
      }


      def _registry():
          reg = sys.modules.get("cdp_registry")
          return reg.blocks if reg is not None else {}


      class Telemetry(gr.basic_block):
          def __init__(self, node_id=1, port=5300, bind_addr="127.0.0.1", period_s=1.0, stall_s=3.0,
                       log_dir="~/.cdp_link", verbose=1):
              gr.basic_block.__init__(self, name="Telemetry + watchdog", in_sig=None, out_sig=None)
              self.node_id = int(node_id)
              self.port = int(port)
              self.bind_addr = str(bind_addr)
              self.period_s = max(0.2, float(period_s))
              self.stall_s = float(stall_s)
              self.log_dir = os.path.expanduser(str(log_dir))
              self.verbose = int(verbose)
              self._run = False
              self._thr = None
              self._sel = None
              self._lsock = None
              self._clients = {}
              self._events = collections.deque(maxlen=300)
              self._new_events = []
              self._active = {}                 # episode key -> start time (a problem is reported once per episode)
              self._prev = {}
              self._t0 = time.monotonic()
              self._log = None
              self._log_path = None
              self._stack_path = None
              self._stack_file = None
              self._threads_prev = {}
              self._proc_prev = None
              self._late_max = 0.0
              self.snapshots = 0
              self._mac = collections.Counter()
              self.message_port_register_in(pmt.intern("mac_in"))
              self.set_msg_handler(pmt.intern("mac_in"), self._on_mac)

          def _on_mac(self, msg):
              try:
                  self._mac[str(pmt.symbol_to_string(msg))] += 1
              except Exception:
                  self._mac["other"] += 1

          # ------------------------------------------------------------------ GNU Radio side
          def start(self):
              os.makedirs(self.log_dir, exist_ok=True)
              self._log_path = os.path.join(self.log_dir, f"telemetry_node{self.node_id}.jsonl")
              self._stack_path = os.path.join(self.log_dir, f"stacks_node{self.node_id}.txt")
              try:
                  import faulthandler
                  import signal
                  self._stack_file = open(self._stack_path, "a")
                  faulthandler.register(signal.SIGUSR1, file=self._stack_file, all_threads=True)
              except Exception as e:
                  print(f"[TELEM] SIGUSR1 stack dumps unavailable: {e}", flush=True)
              self._sel = selectors.DefaultSelector()
              self._lsock = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
              self._lsock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
              try:
                  self._lsock.bind((self.bind_addr, self.port))
                  self._lsock.listen(4)
                  self._lsock.setblocking(False)
                  self._sel.register(self._lsock, selectors.EVENT_READ, None)
              except OSError as e:
                  print(f"[TELEM] cannot listen on {self.bind_addr}:{self.port}: {e} (dashboard can't connect)", flush=True)
                  self._lsock.close()
                  self._lsock = None
              self._run = True
              self._t0 = time.monotonic()
              self._thr = threading.Thread(target=self._loop, name="telemetry", daemon=True)
              self._thr.start()
              print(f"[TELEM] node {self.node_id}: telemetry on tcp://{self.bind_addr}:{self.port}, log {self._log_path}, "
                    f"pid {os.getpid()} (kill -USR1 {os.getpid()} dumps all Python stacks to {self._stack_path})", flush=True)
              return True

          def stop(self):
              self._run = False
              if self._thr is not None:
                  self._thr.join(timeout=2.0)
              for c in list(self._clients):
                  try:
                      c.close()
                  except OSError:
                      pass
              for f in (self._lsock, self._log):
                  try:
                      if f is not None:
                          f.close()
                  except OSError:
                      pass
              return True

          # ------------------------------------------------------------------ worker
          def _loop(self):
              next_t = time.monotonic() + self.period_s
              tick = 0.1
              last = time.monotonic()
              while self._run:
                  for key, _ in self._sel.select(timeout=tick):
                      if key.data is None:
                          self._accept()
                      else:
                          self._client_read(key.fileobj)
                  now = time.monotonic()
                  late = now - last - tick
                  if late > 0:
                      self._late_max = max(self._late_max, late)
                  last = now
                  if now >= next_t:
                      next_t = now + self.period_s
                      try:
                          self._snapshot_and_check()
                      except Exception as e:
                          print(f"[TELEM] snapshot error: {e!r}", flush=True)
                      last = time.monotonic()                      # don't count our own work as lateness

          def _accept(self):
              try:
                  s, _ = self._lsock.accept()
              except OSError:
                  return
              s.setblocking(False)
              self._clients[s] = bytearray()
              self._sel.register(s, selectors.EVENT_READ, "client")

          def _drop(self, s):
              try:
                  self._sel.unregister(s)
              except Exception:
                  pass
              try:
                  s.close()
              except OSError:
                  pass
              self._clients.pop(s, None)

          def _client_read(self, s):
              try:
                  data = s.recv(65536)
              except (BlockingIOError, InterruptedError):
                  return
              except OSError:
                  data = b""
              if not data:
                  return self._drop(s)
              buf = self._clients[s]
              buf += data
              while b"\n" in buf:
                  line, _, rest = bytes(buf).partition(b"\n")
                  buf[:] = rest
                  try:
                      reply = self._command(json.loads(line.decode()))
                  except Exception as e:
                      reply = {"reply": "error", "error": repr(e)}
                  self._send(s, reply)

          def _send(self, s, obj):
              data = (json.dumps(obj, default=str) + "\n").encode()
              try:
                  s.setblocking(True)
                  s.settimeout(0.5)
                  s.sendall(data)
                  s.setblocking(False)
              except OSError:
                  self._drop(s)

          def _command(self, c):
              cmd = c.get("cmd")
              if cmd == "set":
                  target, key, value = c.get("target"), c.get("key"), c.get("value")
                  blk = _registry().get(target)
                  caster = LIVE.get(target, {}).get(key)
                  if blk is None or caster is None:
                      return {"reply": "set", "ok": False, "error": f"{target}.{key} cannot be changed while running"}
                  v = caster(value)
                  if target == "arq" and key == "window":
                      v = max(1, min(32, v))
                  setattr(blk, key, v)
                  if target == "csma" and key == "cw_min":
                      blk._cw = v
                  self._event("info", f"set_{target}_{key}", f"{target}.{key} set to {v} while running")
                  return {"reply": "set", "ok": True, "target": target, "key": key, "value": v}
              if cmd == "stacks":
                  path, text = self.dump_stacks("requested from the dashboard")
                  return {"reply": "stacks", "path": path, "text": text}
              if cmd == "snapshot":
                  return self._snapshot_and_check(send=False)
              return {"reply": "error", "error": f"unknown command {cmd!r}"}

          # ------------------------------------------------------------------ measurements
          def _proc(self, dt):
              tck = os.sysconf("SC_CLK_TCK")
              threads = []
              cur = {}
              try:
                  for tid in os.listdir("/proc/self/task"):
                      try:
                          with open(f"/proc/self/task/{tid}/stat") as f:
                              st = f.read()
                          with open(f"/proc/self/task/{tid}/comm") as f:
                              name = f.read().strip()
                      except OSError:
                          continue
                      fields = st[st.rfind(")") + 2:].split()
                      ticks = int(fields[11]) + int(fields[12])
                      cur[tid] = ticks
                      if tid in self._threads_prev and dt > 0:
                          threads.append((name, 100.0 * (ticks - self._threads_prev[tid]) / tck / dt))
              except OSError:
                  pass
              self._threads_prev = cur
              total = sum(cur.values())
              cpu = None
              if self._proc_prev is not None and dt > 0:
                  cpu = 100.0 * (total - self._proc_prev) / tck / dt
              self._proc_prev = total
              rss = None
              try:
                  with open("/proc/self/status") as f:
                      for line in f:
                          if line.startswith("VmRSS:"):
                              rss = int(line.split()[1]) / 1024.0
              except OSError:
                  pass
              try:
                  load1 = os.getloadavg()[0]
              except OSError:
                  load1 = None
              threads.sort(key=lambda x: -x[1])
              return {"cpu_pct": cpu, "rss_mb": rss, "threads": len(cur), "load1": load1, "cores": os.cpu_count(),
                      "top_threads": [[n, round(p, 1)] for n, p in threads[:8]]}

          def dump_stacks(self, reason):
              names = {t.ident: t.name for t in threading.enumerate()}
              out = [f"===== {datetime.now():%Y-%m-%d %H:%M:%S} node {self.node_id}: {reason}"]
              for tid, frame in sys._current_frames().items():
                  out.append(f"--- thread {names.get(tid, tid)}")
                  out.extend(line.rstrip("\n") for line in traceback.format_stack(frame))
              text = "\n".join(out) + "\n"
              try:
                  with open(self._stack_path, "a") as f:
                      f.write(text)
              except (OSError, TypeError):
                  pass
              return self._stack_path, text

          def _event(self, severity, key, text, data=None, stacks=False):
              ev = {"t": time.time(), "severity": severity, "key": key, "text": text, "data": data or {}}
              if stacks:
                  path, _ = self.dump_stacks(text)
                  ev["stacks"] = path
              self._events.append(ev)
              self._new_events.append(ev)
              if self.verbose:
                  print(f"[WATCHDOG] {severity.upper()}: {text}", flush=True)

          def _episode(self, key, active, severity, text, data=None, stacks=False):
              """Report a problem once when it starts; report again only after it has cleared."""
              if active and key not in self._active:
                  self._active[key] = time.time()
                  self._event(severity, key, text, data, stacks)
              elif not active and key in self._active:
                  dur = time.time() - self._active.pop(key)
                  self._event("info", key + "_cleared", f"cleared after {dur:.0f} s: {key}")

          def _snapshot_and_check(self, send=True):
              now = time.monotonic()
              dt = now - getattr(self, "_t_last_snap", now - self.period_s)
              self._t_last_snap = now
              blocks = {}
              for name, blk in list(_registry().items()):
                  try:
                      blocks[name] = blk.telemetry()
                  except Exception as e:
                      blocks[name] = {"error": repr(e)}
              snap = {"type": "snapshot", "t": time.time(), "node": self.node_id, "uptime_s": now - self._t0,
                      "pid": os.getpid(), "proc": self._proc(dt), "late_ms_max": 1e3 * self._late_max, "blocks": blocks,
                      "arq_mac": dict(self._mac)}
              self._late_max = 0.0
              self._check(snap)
              snap["events_new"], self._new_events = self._new_events, []
              snap["active_problems"] = sorted(self._active)
              self.snapshots += 1
              self._write_log(snap)
              if send:
                  for s in list(self._clients):
                      self._send(s, snap)
              return snap

          def _write_log(self, snap):
              try:
                  if self._log is None or self._log.closed:
                      self._log = open(self._log_path, "a")
                  self._log.write(json.dumps(snap, default=str) + "\n")
                  self._log.flush()
                  if self._log.tell() > 50e6:
                      self._log.close()
                      os.replace(self._log_path, self._log_path + ".1")
                      self._log = None
              except OSError:
                  pass

          # ------------------------------------------------------------------ watchdog rules
          def _check(self, s):
              b, prev = s["blocks"], self._prev
              cs, ar, de, tp = b.get("csma", {}), b.get("arq", {}), b.get("deframer", {}), b.get("txprobe", {})
              age = cs.get("last_work_age_s")
              self._episode("rx_stream_stalled", age is not None and age > self.stall_s, "critical",
                            f"receive stream stopped: no samples from the radio for {age or 0:.1f} s (radio reset, "
                            f"USB/network link lost, or the flowgraph scheduler is blocked)", {"age_s": age}, stacks=True)
              pct = cs.get("rx_rate_pct")
              self._episode("samples_dropped", pct is not None and pct < 99.0, "warning",
                            f"only {pct or 0:.1f} % of the radio's samples arrive: the PC is not keeping up "
                            f"(top threads: {s['proc']['top_threads'][:3]})", {"pct": pct})
              self._episode("csma_tx_phase_stuck", cs.get("self_tx") and (cs.get("phase_age_s") or 0) > 1.0, "critical",
                            f"CSMA stuck in its own transmission (phase {cs.get('phase')}, "
                            f"{cs.get('phase_age_s', 0):.1f} s): receiver is off meanwhile", dict(cs), stacks=True)
              self._episode("csma_queue_waiting", (cs.get("queue") or 0) > 0 and (cs.get("oldest_queued_s") or 0) > 5,
                            "warning", f"{cs.get('queue')} frames wait in the CSMA queue, oldest {cs.get('oldest_queued_s', 0):.0f} s "
                            f"(channel busy {100 * (cs.get('busy_frac') or 0):.0f} %, floor {cs.get('floor_db')} dB)")
              tx_up = cs.get("tx", 0) > prev.get("csma_tx", cs.get("tx", 0))
              tp_up = tp.get("samples", 0) > prev.get("tp_samples", tp.get("samples", 0))
              self._episode("tx_path_stalled", bool(tp) and tx_up and not tp_up and (tp.get("last_age_s") or 0) > self.stall_s,
                            "critical", "CSMA released frames but no samples reach the radio sink: TX path stalled",
                            stacks=True)
              if cs.get("no_echo", 0) > prev.get("csma_no_echo", cs.get("no_echo", 0)):
                  self._event("warning", "no_echo", "own burst not heard on own receiver (TX not transmitting?)")
              mu = cs.get("mute") or {}
              if mu.get("errors", 0) > prev.get("mute_errors", mu.get("errors", 0)):
                  self._event("warning", "mute_errors", f"TX attenuation writes failing ({mu.get('errors')} so far)")
              self._episode("mute_off", bool(mu) and mu.get("enabled") and mu.get("failed"), "warning",
                            f"TX mute could not start ({mu.get('reason')}): own transmitter leaks into own receiver")
              la = ar.get("loop_age_s")
              self._episode("arq_thread_stalled", la is not None and la > 1.0, "critical",
                            f"ARQ worker thread has not run for {la or 0:.1f} s", stacks=True)
              for dest, p in (ar.get("tx") or {}).items():
                  self._episode(f"arq_stuck_{dest}", (p.get("oldest_msg_s") or 0) > 30, "warning",
                                f"message to node {dest} open for {p.get('oldest_msg_s', 0):.0f} s (rto {p.get('rto_s')} s, "
                                f"cwnd {p.get('cwnd')}, {p.get('max_tries_now')} tries on the oldest segment)", p)
              self._episode("deframer_waiting", (de.get("waiting_s") or 0) > 2.0, "warning",
                            f"deframer has waited {de.get('waiting_s', 0):.1f} s for the rest of a frame "
                            f"({de.get('buffer_bits')} bits buffered): a frame tail is held up")
              lm = s["late_ms_max"]
              self._episode("python_stall", lm > 250, "warning",
                            f"Python threads were blocked for {lm:.0f} ms (GIL held by a busy block; top threads: "
                            f"{s['proc']['top_threads'][:3]})")
              hot = [t for t in s["proc"]["top_threads"] if t[1] > 90]
              self._episode("hot_thread", bool(hot), "warning", f"thread at {hot[0][1] if hot else 0:.0f} % of a core: "
                            f"{hot[0][0] if hot else ''} is the bottleneck")
              self._prev = {"csma_tx": cs.get("tx", 0), "tp_samples": tp.get("samples", 0),
                            "csma_no_echo": cs.get("no_echo", 0), "mute_errors": mu.get("errors", 0)}
    bind_addr: os.environ.get('CDP_BIND', '127.0.0.1')
    comment: 'Telemetry + watchdog: snapshots to the dashboard (tcp CDP_TELEM_PORT) and ~/.cdp_link, stall detection, stack dumps.'
    log_dir: SET_LOG_DIR
    node_id: MY_ID
    period_s: '1.0'
    port: SET_TELEM_PORT
    stall_s: '3.0'
    verbose: '1'
  states: {}
- name: epy_txprobe
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: TX probe (sink, for diagnostics)
      Connect a second output line from the TX chain (e.g. the Tag Gate output that feeds the Pluto Sink) to this block.
      It only counts: samples handed to the radio sink, bursts (separated by > 50 ms without samples) and the time of
      the last sample. The Telemetry block reads it: frames released by CSMA while no TX samples flow = TX path stalled.
      """
      import time

      import numpy as np
      from gnuradio import gr


      def _cdp_register(name, blk):
          """Shared registry (one per flowgraph process) read by the Telemetry block."""
          import sys as _sys, types as _types
          reg = _sys.modules.get("cdp_registry")
          if reg is None:
              reg = _types.ModuleType("cdp_registry")
              reg.blocks = {}
              _sys.modules["cdp_registry"] = reg
          reg.blocks[name] = blk


      class TxProbe(gr.sync_block):
          def __init__(self, samp_rate=1.5e6, gap_s=0.05):
              gr.sync_block.__init__(self, name="TX Probe", in_sig=[np.complex64], out_sig=None)
              self.samp_rate = float(samp_rate)
              self.gap_s = float(gap_s)
              self._samples = 0
              self._bursts = 0
              self._last = 0.0
              self._peak = 0.0

          def start(self):
              _cdp_register("txprobe", self)
              return True

          def work(self, input_items, output_items):
              x = input_items[0]
              now = time.monotonic()
              if now - self._last > self.gap_s:
                  self._bursts += 1
              self._last = now
              self._samples += len(x)
              if len(x):
                  self._peak = max(self._peak, float(np.max(np.abs(x[::16]))))
              return len(x)

          def telemetry(self):
              now = time.monotonic()
              peak, self._peak = self._peak, 0.0
              return {"samples": self._samples, "bursts": self._bursts, "airtime_s": self._samples / self.samp_rate,
                      "last_age_s": (now - self._last) if self._last else None, "peak": peak}
    comment: Counts samples going to the Pluto Sink (TX path health for the watchdog).
    gap_s: '0.05'
    samp_rate: samp_rate
  states: {}
- name: epy_udp
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: UDP Transport (unreliable datagrams) + UDP sockets for an external daemon

      Wiring
        Packet Deframer RX pdu_out -> pdu_in        pdu_out -> Packet Framer TX msg_in

      What it does
        One daemon datagram = one radio frame, sent once: no ACK, no retransmission, no ordering, no splitting.
        dest 255 = every node (broadcast). Use it for chat lines, beacons, status, anything where a lost or late
        packet is better than a delayed one. Larger data or anything that must arrive: use the ARQ block.

      On air (inside the framer payload; the framer adds src_id / dest_id):   C5 01 | payload

      Daemon sockets (UDP, plain datagrams)
        daemon -> block : send to  bind_addr:listen_port   datagram = dest 1B | payload
        block -> daemon : sent to  deliver_addr:deliver_port   datagram = src 1B | dest 1B | payload
                          (dest = this node's ID, or 255 if it was a broadcast)
        payload up to max_payload_len - 2 bytes; larger datagrams are dropped with a message.
      """
      import collections
      import socket
      import threading
      import time

      import pmt
      from gnuradio import gr


      def _cdp_register(name, blk):
          """Shared registry (one per flowgraph process) read by the Telemetry block."""
          import sys as _sys, types as _types
          reg = _sys.modules.get("cdp_registry")
          if reg is None:
              reg = _types.ModuleType("cdp_registry")
              reg.blocks = {}
              _sys.modules["cdp_registry"] = reg
          reg.blocks[name] = blk

      MAGIC, P_UDP = 0xC5, 0x01


      class UdpTransport(gr.basic_block):
          def __init__(self, src_id=1, listen_port=5200, deliver_port=5201, bind_addr="127.0.0.1",
                       deliver_addr="127.0.0.1", max_payload_len=2048, verbose=1, stats_every_s=10.0):
              gr.basic_block.__init__(self, name="UDP Transport (datagrams, socket)", in_sig=None, out_sig=None)
              self.src_id = int(src_id)
              self.listen_port = int(listen_port)
              self.deliver_port = int(deliver_port)
              self.bind_addr = str(bind_addr)
              self.deliver_addr = str(deliver_addr)
              self.max_data = max(1, int(max_payload_len) - 2)
              self.verbose = int(verbose)
              self.stats_every_s = float(stats_every_s)
              self._sock = None
              self._out = None
              self._thr = None
              self._run = False
              self._st = collections.Counter()
              self._st_last = collections.Counter()

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self._on_pdu)
              self.message_port_register_out(pmt.intern("pdu_out"))

          def start(self):
              self._out = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self._sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self._sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)
              try:
                  self._sock.bind((self.bind_addr, self.listen_port))
                  self._sock.settimeout(0.2)
              except OSError as e:
                  print(f"[UDP] cannot listen on {self.bind_addr}:{self.listen_port}: {e}. Sending from the daemon "
                        f"disabled.", flush=True)
                  self._sock.close()
                  self._sock = None
              self._run = True
              _cdp_register("udp", self)
              self._thr = threading.Thread(target=self._loop, name="udp", daemon=True)
              self._thr.start()
              print(f"[UDP] node {self.src_id}: daemon sends to udp://{self.bind_addr}:{self.listen_port} "
                    f"(dest 1B + payload, max {self.max_data} B), received datagrams go to "
                    f"udp://{self.deliver_addr}:{self.deliver_port} (src 1B + dest 1B + payload)", flush=True)
              return True

          def stop(self):
              self._run = False
              if self._thr is not None:
                  self._thr.join(timeout=1.0)
              for s in (self._sock, self._out):
                  if s is not None:
                      try:
                          s.close()
                      except OSError:
                          pass
              return True

          def telemetry(self):
              return {"counters": dict(self._st), "listening": self._sock is not None,
                      "listen_port": self.listen_port, "deliver_port": self.deliver_port, "max_data": self.max_data}

          # daemon -> radio
          def _loop(self):
              t_stats = time.monotonic()
              while self._run:
                  if self._sock is not None:
                      try:
                          dgram, addr = self._sock.recvfrom(65535)
                      except socket.timeout:
                          dgram = None
                      except OSError:
                          dgram = None
                          time.sleep(0.2)
                      if dgram:
                          self._from_daemon(dgram)
                  else:
                      time.sleep(0.2)
                  if self.verbose and self.stats_every_s > 0 and time.monotonic() - t_stats >= self.stats_every_s:
                      t_stats = time.monotonic()
                      d = {k: self._st[k] - self._st_last[k] for k in ("tx", "rx", "bcast", "rejected", "senderr")}
                      if any(d.values()):
                          print(f"[UDP] since last line: sent {d['tx']} (broadcast {d['bcast']}), received {d['rx']}, "
                                f"rejected {d['rejected']}, local send errors {d['senderr']}", flush=True)
                      self._st_last = collections.Counter(self._st)

          def _from_daemon(self, dgram):
              dest, data = dgram[0], dgram[1:]
              if not data or len(data) > self.max_data or dest == self.src_id:
                  self._st["rejected"] += 1
                  why = ("empty" if not data else f"{len(data)} B > {self.max_data} B" if len(data) > self.max_data
                         else "dest is this node")
                  print(f"[UDP] datagram to {dest} dropped: {why}", flush=True)
                  return
              raw = bytes([MAGIC, P_UDP]) + data
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(int(dest)))
              self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, pmt.init_u8vector(len(raw), list(raw))))
              self._st["tx"] += 1
              if dest == 255:
                  self._st["bcast"] += 1

          # radio -> daemon
          def _on_pdu(self, msg):
              try:
                  meta, data = pmt.car(msg), pmt.cdr(msg)
                  if not pmt.is_u8vector(data):
                      return
                  raw = bytes(pmt.u8vector_elements(data))
                  if len(raw) < 2 or raw[0] != MAGIC or raw[1] != P_UDP:
                      return
                  src = pmt.to_long(pmt.dict_ref(meta, pmt.intern("src_id"), pmt.from_long(0)))
                  dst = pmt.to_long(pmt.dict_ref(meta, pmt.intern("dest_id"), pmt.from_long(self.src_id)))
              except Exception:
                  return
              self._st["rx"] += 1
              try:
                  self._out.sendto(bytes([src & 0xFF, dst & 0xFF]) + raw[2:], (self.deliver_addr, self.deliver_port))
              except OSError:
                  self._st["senderr"] += 1
    bind_addr: os.environ.get('CDP_BIND', '127.0.0.1')
    comment: UDP transport. Daemon sends to udp://CDP_BIND:CDP_UDP_PORT (5200), gets datagrams on CDP_UDP_OUT_PORT (5201).
    deliver_addr: os.environ.get('CDP_UDP_DELIVER', '127.0.0.1')
    deliver_port: int(os.environ.get('CDP_UDP_OUT_PORT', '5201'))
    listen_port: int(os.environ.get('CDP_UDP_PORT', '5200'))
    max_payload_len: max_payload_len
    src_id: MY_ID
    stats_every_s: '10.0'
    verbose: '1'
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: FILTER_BW
    buffer_size: BUFFER_SIZE
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: TX_FREQ
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: FILTER_BW
    bbdc: 'True'
    buffer_size: BUFFER_SIZE
    filter_source: '''Auto'''
    frequency: RX_FREQ
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import numpy as np
      import os
  states: {}
- name: note_0
  id: note
  parameters:
    note: v6.8 = v6.7 + CSMA->ARQ on-air feedback (tx_start -> mac_in), priority queueing of ACKs/resends, on-air-order loss detection, timeout probe. Start it from cdp_link_app.py.
  states: {}
- name: note_1
  id: note
  parameters:
    note: To observe signal power
  states: {}
- name: note_settings
  id: note
  parameters:
    note: 'SETTINGS: every SET_* variable reads its start value from an environment variable (cdp_link_app.py sets them from its Settings tab). Timeouts and CSMA timing can also be changed while running from the dashboard.'
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message (@N text = to node N, @all text = everyone)"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0'
    ymin: '-55'
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', blocks_copy_1_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_1, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0_0, '0', epy_txprobe, '0']
- [blocks_tag_gate_0_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_5_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', virtual_sink_5_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [dc_blocker_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [dc_blocker_xx_0, '0', blocks_copy_1_1, '0']
- [dc_blocker_xx_0, '0', epy_csma, '0']
- [dc_blocker_xx_0, '0', epy_noise, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_corr, '0']
- [epy_arq, mac_ctrl, epy_telem, mac_in]
- [epy_arq, pdu_out, epy_block_0_0_1, msg_in]
- [epy_block_0, msg_out, epy_block_0_0_1, msg_in]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0_0, pdu_out, epy_arq, pdu_in]
- [epy_block_0_0_0, pdu_out, epy_block_1, pdu_in]
- [epy_block_0_0_0, pdu_out, epy_udp, pdu_in]
- [epy_block_0_0_1, pdu_out, epy_csma, pdu_in]
- [epy_block_corr, '0', blocks_tag_debug_corr, '0']
- [epy_block_corr, '0', digital_linear_equalizer_0, '0']
- [epy_csma, '0', analog_pwr_squelch_xx_0_0, '0']
- [epy_csma, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_csma, tx_start, epy_arq, mac_in]
- [epy_udp, pdu_out, epy_block_0_0_1, msg_in]
- [iio_pluto_source_0, '0', dc_blocker_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0, msg_in]
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0_1, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', blocks_copy_0_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
