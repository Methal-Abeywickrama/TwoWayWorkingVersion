options:
  parameters:
    description: Bridges two copies of fps_game.py through a simulated lossy link. Replace each chan_* block with your TX->air->RX chain.
    generate_options: no_gui
    id: game_pdu_bridge
    output_language: python
    run_options: run
    title: Game PDU bridge (no radio)
  states: {}

blocks:
- name: drop_prob
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: corrupt_prob
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: delay_ms
  id: variable
  parameters:
    value: '20'
  states: {}
- name: game0_tx
  id: network_socket_pdu
  parameters:
    comment: game --id 0 sends here
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: chan_0to1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Lossy PDU Channel (testing only)

      Stands in for the radio in game_pdu_bridge.grc: drops PDUs with probability drop_prob,
      flips one random bit with probability corrupt_prob, and can add a fixed delay.
      Lets you see how the game behaves with a bad link before using the ANTSDRs.
      """
      import random
      import threading

      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Lossy PDU Channel - drop / corrupt / delay PDUs to mimic a radio link."""

          def __init__(self, drop_prob=0.0, corrupt_prob=0.0, delay_ms=0.0, seed=0):
              gr.basic_block.__init__(self, name="Lossy PDU Channel", in_sig=None, out_sig=None)
              self.drop_prob = drop_prob
              self.corrupt_prob = corrupt_prob
              self.delay_ms = delay_ms
              self.rng = random.Random(seed if seed else None)
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle)

          def handle(self, msg):
              if self.rng.random() < self.drop_prob:
                  return
              if self.rng.random() < self.corrupt_prob and pmt.is_pair(msg):
                  data = list(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data:
                      i = self.rng.randrange(len(data))
                      data[i] ^= 1 << self.rng.randrange(8)
                      msg = pmt.cons(pmt.car(msg), pmt.init_u8vector(len(data), data))
              if self.delay_ms > 0:
                  threading.Timer(self.delay_ms / 1000.0, self.message_port_pub,
                                  (pmt.intern("out"), msg)).start()
              else:
                  self.message_port_pub(pmt.intern("out"), msg)
    comment: 'stands in for: your TX chain -> air -> RX chain'
    corrupt_prob: corrupt_prob
    delay_ms: delay_ms
    drop_prob: drop_prob
    seed: '0'
  states: {}
- name: game1_rx
  id: network_socket_pdu
  parameters:
    comment: game --id 1 listens here
    host: 127.0.0.1
    mtu: '10000'
    port: '52012'
    type: UDP_CLIENT
  states: {}
- name: game1_tx
  id: network_socket_pdu
  parameters:
    comment: game --id 1 sends here
    mtu: '10000'
    port: '52011'
    type: UDP_SERVER
  states: {}
- name: chan_1to0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Lossy PDU Channel (testing only)

      Stands in for the radio in game_pdu_bridge.grc: drops PDUs with probability drop_prob,
      flips one random bit with probability corrupt_prob, and can add a fixed delay.
      Lets you see how the game behaves with a bad link before using the ANTSDRs.
      """
      import random
      import threading

      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Lossy PDU Channel - drop / corrupt / delay PDUs to mimic a radio link."""

          def __init__(self, drop_prob=0.0, corrupt_prob=0.0, delay_ms=0.0, seed=0):
              gr.basic_block.__init__(self, name="Lossy PDU Channel", in_sig=None, out_sig=None)
              self.drop_prob = drop_prob
              self.corrupt_prob = corrupt_prob
              self.delay_ms = delay_ms
              self.rng = random.Random(seed if seed else None)
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle)

          def handle(self, msg):
              if self.rng.random() < self.drop_prob:
                  return
              if self.rng.random() < self.corrupt_prob and pmt.is_pair(msg):
                  data = list(pmt.u8vector_elements(pmt.cdr(msg)))
                  if data:
                      i = self.rng.randrange(len(data))
                      data[i] ^= 1 << self.rng.randrange(8)
                      msg = pmt.cons(pmt.car(msg), pmt.init_u8vector(len(data), data))
              if self.delay_ms > 0:
                  threading.Timer(self.delay_ms / 1000.0, self.message_port_pub,
                                  (pmt.intern("out"), msg)).start()
              else:
                  self.message_port_pub(pmt.intern("out"), msg)
    comment: 'stands in for: your TX chain -> air -> RX chain'
    corrupt_prob: corrupt_prob
    delay_ms: delay_ms
    drop_prob: drop_prob
    seed: '0'
  states: {}
- name: game0_rx
  id: network_socket_pdu
  parameters:
    comment: game --id 0 listens here
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    type: UDP_CLIENT
  states: {}

connections:
- [game0_tx, pdus, chan_0to1, in]
- [chan_0to1, out, game1_rx, pdus]
- [game1_tx, pdus, chan_1to0, in]
- [chan_1to0, out, game0_rx, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
