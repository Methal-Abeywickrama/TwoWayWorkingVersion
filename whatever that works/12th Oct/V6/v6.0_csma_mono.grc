options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: BUFFER_SIZE
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: FEC
  id: variable
  parameters:
    comment: |-
      0 = no FEC
      15 = Hamming(15,11)
      31 = Hamming(31,26)
    value: '31'
  states: {}
- name: FILTER_BW
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: FREQ
  id: variable
  parameters:
    comment: Single frequency (half duplex, CSMA). Both nodes TX and RX here.
    value: TX_FREQ_A
  states: {}
- name: MY_ID
  id: variable
  parameters:
    value: '1'
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: RC_PULSE
  id: variable
  parameters:
    value: np.sinc(RC_X)*np.cos(np.pi*alpha*RC_X)/(1-(2*alpha*RC_X)**2)
  states: {}
- name: RC_X
  id: variable
  parameters:
    value: np.arange(-8, 9)/2.0
  states: {}
- name: RX_AMP
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: RX_FREQ
  id: variable
  parameters:
    value: FREQ
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: TRAIN_BITS
  id: variable
  parameters:
    value: np.unpackbits(np.frombuffer(bytes([0xF8, 0xDD, 0x42, 0x58]), np.uint8))
  states: {}
- name: TRAIN_REF
  id: variable
  parameters:
    value: list(map(complex, RX_AMP*np.convolve(np.kron(TRAIN_SYMS, [1, 0]), RC_PULSE)[8:8+2*len(TRAIN_SYMS)-1]))
  states: {}
- name: TRAIN_SYMS
  id: variable
  parameters:
    value: list(map(complex, 1 - 2*np.bitwise_xor.accumulate(TRAIN_BITS).astype(int)))
  states: {}
- name: TX_FREQ
  id: variable
  parameters:
    value: FREQ
  states: {}
- name: TX_FREQ_A
  id: variable
  parameters:
    value: int(1250e6)
  states: {}
- name: TX_FREQ_B
  id: variable
  parameters:
    value: int(1270e6)
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    step_size: '0.5'
    type: nlms
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: corr_thr
  id: variable_qtgui_range
  parameters:
    comment: Normalized correlation threshold (0..1). Random data ~0.1-0.25, real train word ~0.8-1.0.
    start: '0.3'
    step: '0.01'
    stop: '0.98'
    value: '0.7'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.06'
  states: {}
- name: cs_margin
  id: variable_qtgui_range
  parameters:
    label: CSMA sense margin (dB)
    start: '3'
    step: '0.5'
    stop: '15'
    value: '6'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: margin_db
  id: variable_qtgui_range
  parameters:
    label: Squelch margin over noise (dB)
    start: '2'
    step: '0.5'
    stop: '20'
    value: '6'
  states: {}
- name: max_payload_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: power_threshold
  id: variable_function_probe
  parameters:
    block_id: epy_noise
    comment: Automatic squelch threshold (dB) from the noise-floor tracker
    function_name: level
    poll_rate: '5'
    value: '-40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.020'
  states: {}
- name: train_delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '12'
    value: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '5e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-3'
    gate: 'True'
    ramp: '0'
    threshold: power_threshold
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_corr
  id: blocks_tag_debug
  parameters:
    filter: '"corr_est"'
    name: corr_est
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '32'
    lengthtagname: '''packet_len'''
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Bypassed. Enable if [SQL] noise floor jumps after this node's first transmission (own LO leakage at 0 Hz).
    length: '128'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    adapt_after_training: 'False'
    alg: adpt_alg
    num_taps: '7'
    sps: '2'
    training_sequence: TRAIN_SYMS
    training_start_tag: '"corr_est"'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '0.05'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Test Traffic TX  (packet generator + TX log)

      Connect:  msg_out  ->  Packet Framer TX  msg_in      (the QT message edit box can stay connected too)

      Sends test packets following a test plan and writes one CSV row per packet (wall-clock timestamp
      and the exact payload) to  <log_dir>/tx_<date>_<time>_run<id>.csv

      test_plan (string):  "SIZExCOUNT@INTERVAL; SIZExCOUNT@INTERVAL; ..."
          "20x50@0.5; 200x50@0.5; 1000x50@1; 2000x30@1.5"
          SIZE      payload bytes, including the 8-byte test header (min 8, max max_payload_len)
          COUNT     packets in this set
          INTERVAL  seconds between packet starts; "ms" suffix allowed: 100x50@250ms
          optional set names:  "short:20x50@0.5; long:2000x30@1.5"
        A Python list also works:  [(20, 50, 0.5), (200, 50, 0.5, "medium")]

      Payload = [A5 5A][run_id: 2 B][seq: 4 B][fill]
          payload_mode "ascii"  : readable text (default; keeps the framer/deframer console prints clean)
                       "random" : reproducible pseudo-random bytes (most representative for the PHY)
                       "fixed"  : fill_byte repeated
      The RX logger and analyze_link.py match packets by (run_id, seq).

      A run starts start_delay seconds after the flowgraph starts (autostart=1), or whenever any message
      arrives on the ctrl port (e.g. a QT GUI Msg Push Button). A ctrl message containing "stop" ends the run.
      Each run gets a new random run_id and its own log file.
      Timestamps are wall-clock (time.time) in microseconds; keep both PCs NTP-synced for one-way latency.
      Note: the timestamp is when the packet is handed to the framer, not when it is on air. If the interval
      is shorter than the airtime, packets queue in the TX chain and the measured latency grows.
      """
      import csv
      import datetime
      import os
      import re
      import socket
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr

      MAGIC = b"\xA5\x5A"
      TEST_HDR_LEN = 8                       # magic(2) + run_id(2) + seq(4)
      ASCII_TEXT = b"The quick brown fox jumps over the lazy dog 0123456789. "
      TX_FIELDS = ["run_id", "seq", "loop", "set_idx", "set_name", "size", "interval_s",
                   "tx_time_us", "tx_time_iso", "late_ms", "host", "payload_mode", "payload_hex"]


      def parse_plan(plan):
          """Returns [(name, size, count, interval_s), ...] from a plan string or list."""
          entries = []
          if isinstance(plan, str):
              items = [s.strip() for s in re.split(r"[;\n]", plan) if s.strip()]
              for i, item in enumerate(items):
                  name = None
                  if ":" in item:
                      name, item = item.split(":", 1)
                      name = name.strip() or None
                  m = re.fullmatch(r"\s*(\d+)\s*[xX*]\s*(\d+)\s*@\s*([0-9]*\.?[0-9]+)\s*(ms|s)?\s*", item)
                  if not m:
                      raise ValueError(f"test_plan entry '{item}': use SIZExCOUNT@INTERVAL, e.g. 100x50@0.5")
                  size, count, iv = int(m.group(1)), int(m.group(2)), float(m.group(3))
                  if m.group(4) == "ms":
                      iv /= 1000.0
                  entries.append((name or f"set{i}_{size}B", size, count, iv))
          else:
              for i, e in enumerate(plan):
                  if isinstance(e, dict):
                      size, count, iv, name = int(e["size"]), int(e["count"]), float(e["interval"]), e.get("name")
                  else:
                      size, count, iv = int(e[0]), int(e[1]), float(e[2])
                      name = str(e[3]) if len(e) > 3 else None
                  entries.append((name or f"set{i}_{size}B", size, count, iv))
          return entries


      class TestTrafficTX(gr.basic_block):
          def __init__(self, test_plan="20x50@0.5; 200x50@0.5; 1000x50@1.0", repeat_plan=1,
                       start_delay=5.0, set_gap=2.0, payload_mode="ascii", fill_byte=0x55,
                       max_payload_len=2048, log_dir="~/link_tests", autostart=1):
              gr.basic_block.__init__(self, name="Test Traffic TX", in_sig=None, out_sig=None)
              self.test_plan = test_plan
              self.repeat_plan = max(1, int(repeat_plan))
              self.start_delay = max(0.0, float(start_delay))
              self.set_gap = max(0.0, float(set_gap))
              self.payload_mode = str(payload_mode).lower()
              self.fill_byte = int(fill_byte) & 0xFF
              self.max_payload_len = int(max_payload_len)
              self.log_dir = str(log_dir)
              self.autostart = int(autostart)
              if self.payload_mode not in ("ascii", "random", "fixed"):
                  raise ValueError("payload_mode must be 'ascii', 'random' or 'fixed'")
              self._plan = self._checked_plan(test_plan)       # a bad plan raises here -> visible in GRC
              self._host = socket.gethostname()
              self._thread = None
              self._stop_evt = threading.Event()
              self._lock = threading.Lock()

              self._port_out = pmt.intern("msg_out")
              self.message_port_register_out(self._port_out)
              self.message_port_register_in(pmt.intern("ctrl"))
              self.set_msg_handler(pmt.intern("ctrl"), self._handle_ctrl)

          # ---------------------------------------------------------------- plan
          def _checked_plan(self, plan):
              out = []
              for name, size, count, iv in parse_plan(plan):
                  s = max(size, TEST_HDR_LEN)
                  if self.max_payload_len > 0:
                      s = min(s, self.max_payload_len)
                  if s != size:
                      print(f"[TEST TX] set '{name}': size {size} B -> {s} B "
                            f"(min {TEST_HDR_LEN}, max {self.max_payload_len})", flush=True)
                  if count <= 0 or iv < 0:
                      raise ValueError(f"set '{name}': count must be > 0 and interval >= 0")
                  out.append((name, s, count, iv))
              if not out:
                  raise ValueError("test_plan is empty")
              return out

          # ---------------------------------------------------------------- run control
          def start(self):
              if self.autostart:
                  self._launch(self.start_delay)
              return True

          def stop(self):
              self._halt()
              return True

          def _launch(self, delay):
              with self._lock:
                  self._halt_locked()
                  self._stop_evt = threading.Event()
                  self._thread = threading.Thread(target=self._run_safe, args=(delay, self._stop_evt), daemon=True)
                  self._thread.start()

          def _halt(self):
              with self._lock:
                  return self._halt_locked()

          def _halt_locked(self):
              running = self._thread is not None and self._thread.is_alive()
              if running:
                  self._stop_evt.set()
                  self._thread.join(timeout=3.0)
              self._thread = None
              return running

          def _handle_ctrl(self, msg):
              try:
                  if pmt.is_pair(msg):
                      txt = f"{pmt.to_python(pmt.car(msg))} {pmt.to_python(pmt.cdr(msg))}"
                  else:
                      txt = str(pmt.to_python(msg))
              except Exception:
                  txt = ""
              if "stop" in txt.lower():
                  if self._halt():
                      print("[TEST TX] run stopped by ctrl message", flush=True)
              else:
                  print("[TEST TX] new run requested by ctrl message", flush=True)
                  self._launch(0.0)

          # ---------------------------------------------------------------- payload
          def _make_payload(self, run_id, seq, size):
              hdr = MAGIC + run_id.to_bytes(2, "big") + (seq & 0xFFFFFFFF).to_bytes(4, "big")
              n = size - len(hdr)
              if n <= 0:
                  return hdr
              if self.payload_mode == "random":
                  rng = np.random.default_rng((run_id << 32) | seq)
                  fill = rng.integers(0, 256, n, dtype=np.uint8).tobytes()
              elif self.payload_mode == "ascii":
                  base = b"#%07d " % seq + ASCII_TEXT
                  fill = (base * (n // len(base) + 1))[:n]
              else:
                  fill = bytes([self.fill_byte]) * n
              return hdr + fill

          # ---------------------------------------------------------------- worker thread
          def _run_safe(self, delay, stop_evt):
              try:
                  self._run(delay, stop_evt)
              except Exception as e:                      # never die silently in a thread
                  print(f"[TEST TX] ERROR: {e!r}", flush=True)

          def _run(self, delay, stop_evt):
              if stop_evt.wait(delay):
                  return
              run_id = int.from_bytes(os.urandom(2), "big")
              d = os.path.expanduser(self.log_dir)
              os.makedirs(d, exist_ok=True)
              path = os.path.join(d, f"tx_{datetime.datetime.now():%Y%m%d_%H%M%S}_run{run_id:04x}.csv")
              total = sum(c for _, _, c, _ in self._plan) * self.repeat_plan
              print(f"[TEST TX] run {run_id:04x}: {len(self._plan)} sets x {self.repeat_plan} loop(s), "
                    f"{total} packets, log -> {path}", flush=True)

              seq, max_late, n_late = 0, 0.0, 0
              with open(path, "w", newline="") as f:
                  w = csv.writer(f)
                  w.writerow(TX_FIELDS)
                  f.flush()
                  for loop in range(self.repeat_plan):
                      for set_idx, (name, size, count, iv) in enumerate(self._plan):
                          print(f"[TEST TX] run {run_id:04x} loop {loop + 1}/{self.repeat_plan} set {set_idx + 1}/"
                                f"{len(self._plan)} '{name}': {count} x {size} B every {iv:g} s", flush=True)
                          t_next = time.monotonic()
                          for _ in range(count):
                              wait = t_next - time.monotonic()
                              if wait > 0 and stop_evt.wait(wait):
                                  print(f"[TEST TX] run {run_id:04x} stopped after {seq} packets", flush=True)
                                  return
                              late = max(0.0, -wait)
                              max_late = max(max_late, late)
                              if iv > 0 and late > 0.1 * iv:
                                  n_late += 1
                              payload = self._make_payload(run_id, seq, size)
                              t_us = time.time_ns() // 1000
                              self.message_port_pub(self._port_out,
                                                    pmt.cons(pmt.make_dict(),
                                                             pmt.init_u8vector(len(payload), list(payload))))
                              w.writerow([run_id, seq, loop, set_idx, name, size, iv, t_us,
                                          datetime.datetime.fromtimestamp(t_us / 1e6).isoformat(timespec="milliseconds"),
                                          f"{late * 1000:.2f}", self._host, self.payload_mode, payload.hex()])
                              f.flush()
                              seq += 1
                              t_next += iv
                          if self.set_gap > 0 and stop_evt.wait(self.set_gap):
                              print(f"[TEST TX] run {run_id:04x} stopped after {seq} packets", flush=True)
                              return
              msg = f"[TEST TX] run {run_id:04x} DONE: {seq} packets sent, max scheduling lateness {max_late * 1000:.1f} ms"
              if n_late:
                  msg += f" ({n_late} packets >10% of their interval late: this PC cannot keep that rate)"
              print(msg, flush=True)
    autostart: '1'
    fill_byte: '"FF"'
    log_dir: '"~/link_tests"'
    max_payload_len: max_payload_len
    payload_mode: '"ascii"'
    repeat_plan: '1'
    set_gap: '2'
    start_delay: '5'
    test_plan: '"20x50@0.5; 200x50@0.5; 1000x50@1.0"'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Burst Packet Framer TX (with equalizer training word)
      - Outputs packed byte PDUs directly to pdu_pdu_to_tagged_stream
      - Zero idle transmission between bursts
      - Frame layout: [preamble] [train word: F8 DD 42 58] [1A CF FC 1D] [len: 2B][dest_id: 1B][msg_id: 1B][rep: 1B][n_reps: 1B] [payload] [CRC32: 4B] [postamble]
      - The train word is known to the RX: the correlator (digital_corr_est_cc) finds it, tags it,
        and the linear equalizer trains on it. The deframer does not look at it (it only looks for the sync word).
      - Postamble dynamically padded so total size is a multiple of buffer_size
      - Attaches tx_sob (Start of Burst) and tx_eob (End of Burst) metadata tags
      """
      import zlib
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      # 31-bit m-sequence + 1 pad bit. MUST match TRAIN_BITS in the flowgraph (RX side).
      TRAIN_WORD = bytes([0xF8, 0xDD, 0x42, 0x58])


      class PacketFramerTX(gr.basic_block):
          def __init__(
              self,
              peer_id=1,
              preamble_len=64,
              repeat_count=5,
              max_payload_len=1024,
              preamble_byte=0xFF,
              buffer_size=512,
              postamble_byte=0x00,
              train_enable=1,
          ):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst)",
                  in_sig=None,
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.buffer_size = int(buffer_size)
              self.postamble_byte = int(postamble_byte) & 0xFF
              self.train_enable = int(train_enable)
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def handle_msg(self, msg):
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return

              if not payload:
                  return

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[: self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              preamble = bytes([self.preamble_byte]) * self.preamble_len
              train = TRAIN_WORD if self.train_enable else b""
              print(
                  f"[TX] msg #{msg_id} (to peer {self.peer_id}): '{payload.decode('utf-8', 'replace')}' ({n_reps} bursts queued)",
                  flush=True,
              )

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([self.peer_id, msg_id, rep, n_reps])
                  crc = zlib.crc32(header + payload).to_bytes(4, "big")

                  # Core frame structure before buffer alignment
                  raw_frame = preamble + train + SYNC_WORD + header + payload + crc

                  # Calculate postamble padding required to match buffer_size multiple
                  if self.buffer_size > 0:
                      rem = len(raw_frame) % self.buffer_size
                      pad_len = (self.buffer_size - rem) % self.buffer_size
                  else:
                      pad_len = 0

                  postamble = bytes([self.postamble_byte]) * pad_len
                  frame = raw_frame + postamble

                  # Build metadata dictionary with tx_sob and tx_eob tags
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("tx_sob"), pmt.PMT_T)
                  meta = pmt.dict_add(meta, pmt.intern("tx_eob"), pmt.PMT_T)

                  # Explicit offset tags for downstream PDU-to-Tagged-Stream conversion
                  sob_tag = pmt.make_tuple(pmt.from_long(0), pmt.intern("tx_sob"), pmt.PMT_T)
                  eob_tag = pmt.make_tuple(pmt.from_long(len(frame) - 1), pmt.intern("tx_eob"), pmt.PMT_T)
                  extra_tags = pmt.list2(sob_tag, eob_tag)
                  meta = pmt.dict_add(meta, pmt.intern("extra_tags"), extra_tags)

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
    buffer_size: BUFFER_SIZE
    max_payload_len: max_payload_len
    peer_id: '1'
    postamble_byte: '0xFF'
    preamble_byte: '0xFF'
    preamble_len: '128'
    repeat_count: '1'
    train_enable: '1'
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Fast Burst Packet Deframer RX (with Hamming FEC)
      - Vectorized NumPy sliding-window sync detection (fast C execution, minimal GIL load)
      - Positive correlation search only (180-deg phase ambiguity resolved upstream by diff decoder)
      - 1-bit false sync backtracking (prevents dropped frames on noise triggers)
      - fec = 0 / 15 / 31 and interleave must match the TX framer
      - Hamming decode: header section first (gives the length), then payload+CRC section
      - Full CRC32 verification over header + payload (after FEC correction)
      - Destination address filtering: drops frames where dest_id != peer_id
      - Message deduplication: displays payload once per msg_id, then logs burst statistics
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      HDR_BYTES = 6  # len (2B) + dest_id (1B) + msg_id (1B) + rep (1B) + n_reps (1B)


      def hamming_tables(n):
          """Standard positional Hamming layout: parity bits at positions 1, 2, 4, 8, (16)."""
          m = {15: 4, 31: 5}[n]
          pos = np.arange(1, n + 1)
          is_parity = (pos & (pos - 1)) == 0
          data_idx = np.flatnonzero(~is_parity)
          H = ((pos[None, :] >> np.arange(m)[:, None]) & 1).astype(np.int32)   # m x n, column j = bin(j)
          weights = (1 << np.arange(m)).astype(np.int32)
          return data_idx, H, weights


      def hamming_decode_bits(coded, n, nblk, interleave):
          """coded: nblk*n bits. Returns (data bits nblk*k, number of corrected bits)."""
          data_idx, H, weights = hamming_tables(n)
          c = np.asarray(coded, dtype=np.int32)
          cw = c.reshape(n, nblk).T.copy() if interleave else c.reshape(nblk, n).copy()
          S = ((cw @ H.T) & 1) @ weights          # syndrome = error position (1..n), 0 = no error
          bad = np.flatnonzero(S)
          cw[bad, S[bad] - 1] ^= 1                # flip bit at position S
          return cw[:, data_idx].reshape(-1).astype(np.uint8), int(bad.size)


      class PacketDeframerRX(gr.sync_block):
          def __init__(self, peer_id=1, max_bit_errors=2, max_payload_len=1024, bit_rate=375000,
                       fec=15, interleave=True):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX (Fast Burst, Hamming)",
                  in_sig=[np.uint8],
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.bit_rate = float(bit_rate)
              self.fec = int(fec)
              self.interleave = bool(interleave)
              if self.fec not in (0, 15, 31):
                  raise ValueError("fec must be 0, 15 or 31")

              # Bipolar template (+1 / -1) for correlation
              self._sync = np.unpackbits(np.frombuffer(SYNC_WORD, np.uint8)).astype(np.int16) * 2 - 1
              self._buf = np.zeros(0, dtype=np.uint8)

              self.n_sync = 0
              self.n_ok = 0
              self.n_crc_fail = 0
              self.n_bad_len = 0
              self.n_fec_corrected = 0      # total bits corrected by Hamming in CRC-valid frames

              self._bits_total = 0
              self._bits_at_last_ok = 0
              self._cur_id = None
              self._cur_reps = set()
              self._cur_nreps = 0
              self._cur_corr = 0

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("text_out"))

          # ---------- section sizes (in channel bits) ----------
          def _coded_len(self, n_bytes):
              if self.fec == 0:
                  return n_bytes * 8, 0
              nblk = -(-(n_bytes * 8) // {15: 11, 31: 26}[self.fec])
              return nblk * self.fec, nblk

          def _decode_section(self, coded, n_bytes, nblk):
              if self.fec == 0:
                  return np.packbits(coded).tobytes(), 0
              bits, corr = hamming_decode_bits(coded, self.fec, nblk, self.interleave)
              return np.packbits(bits[:n_bytes * 8]).tobytes(), corr

          # ---------- statistics / delivery ----------
          def _flush_summary(self):
              if self._cur_id is not None:
                  got, n = len(self._cur_reps), self._cur_nreps
                  loss = 100.0 * (n - got) / max(n, 1)
                  fec_txt = f", FEC corrected {self._cur_corr} bits" if self.fec else ""
                  print(f"[RX] msg #{self._cur_id}: {got}/{n} bursts OK (Loss: {loss:.0f}%){fec_txt}", flush=True)
              self._cur_id = None
              self._cur_reps = set()
              self._cur_corr = 0

          def _deliver(self, header, payload, corrected):
              dest_id, msg_id, rep, n_reps = header[2], header[3], header[4], header[5]
              if msg_id != self._cur_id:
                  self._flush_summary()
                  self._cur_id, self._cur_nreps = msg_id, n_reps
                  text = payload.decode("utf-8", errors="replace")
                  print("\n" + "=" * 40, flush=True)
                  print(f"[RX RECEIVED] #{msg_id}: {text}", flush=True)
                  print("=" * 40 + "\n", flush=True)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dest_id))
                  meta = pmt.dict_add(meta, pmt.intern("msg_id"), pmt.from_long(msg_id))
                  meta = pmt.dict_add(meta, pmt.intern("n_reps"), pmt.from_long(n_reps))
                  meta = pmt.dict_add(meta, pmt.intern("fec_corrected"), pmt.from_long(corrected))
                  vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
                  self.message_port_pub(pmt.intern("text_out"), pmt.intern(text))

              if rep not in self._cur_reps:
                  self._cur_corr += corrected
              self._cur_reps.add(rep)
              self._bits_at_last_ok = self._bits_total

          # ---------- main loop ----------
          def work(self, input_items, output_items):
              bits = input_items[0] & 1
              self._bits_total += len(bits)
              self._buf = np.concatenate((self._buf, bits)) if len(self._buf) else bits.copy()

              # Flush transmission stats once channel has been quiet for > 0.5s of air time
              if self._cur_id is not None and self._bits_total - self._bits_at_last_ok > 0.5 * self.bit_rate:
                  self._flush_summary()

              thr = 32 - 2 * self.max_bit_errors
              hdr_coded, hdr_blk = self._coded_len(HDR_BYTES)
              hdr_bits = 32 + hdr_coded

              while True:
                  buf = self._buf
                  if len(buf) < hdr_bits:
                      return len(bits)

                  # Fast matrix dot product over 32-bit window (only positive peaks)
                  pm = buf.astype(np.int16) * 2 - 1
                  corr = np.lib.stride_tricks.sliding_window_view(pm, 32) @ self._sync
                  cand = np.flatnonzero(corr >= thr)

                  if cand.size == 0:
                      self._buf = buf[-31:].copy()  # Preserve trailing bits that might begin a sync word
                      return len(bits)

                  i = int(cand[0])

                  if len(buf) < i + hdr_bits:
                      self._buf = buf[i:].copy()  # Await complete header bits
                      return len(bits)

                  header, hdr_corr = self._decode_section(buf[i + 32 : i + hdr_bits], HDR_BYTES, hdr_blk)
                  length = int.from_bytes(header[:2], "big")

                  if length == 0 or length > self.max_payload_len:
                      self.n_bad_len += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync
                      continue

                  body_coded, body_blk = self._coded_len(length + 4)
                  end = i + hdr_bits + body_coded
                  if len(buf) < end:
                      self._buf = buf[i:].copy()  # Await complete frame body bits
                      return len(bits)

                  body, body_corr = self._decode_section(buf[i + hdr_bits : end], length + 4, body_blk)
                  payload, rx_crc = body[:length], body[length:]
                  self.n_sync += 1

                  if zlib.crc32(header + payload) == int.from_bytes(rx_crc, "big"):
                      corrected = hdr_corr + body_corr
                      self.n_fec_corrected += corrected
                      dest_id = header[2]
                      if dest_id == self.peer_id:
                          self.n_ok += 1
                          self._deliver(header, payload, corrected)
                      # Frame addressed to another peer: discard silently
                      self._buf = buf[end:].copy()  # Advance past valid frame
                  else:
                      self.n_crc_fail += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync

              return len(bits)
    bit_rate: '375000'
    fec: FEC
    interleave: 'True'
    max_bit_errors: '1'
    max_payload_len: max_payload_len
    peer_id: (1-MY_ID)
  states: {}
- name: epy_block_0_0_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Burst Packet Framer TX (Hamming FEC + equalizer training word)
      - Outputs packed byte PDUs directly to pdu_pdu_to_tagged_stream
      - Frame layout:
          [preamble] [train word: F8 DD 42 58] [sync: 1A CF FC 1D] [coded section(s)] [postamble]
        Before coding the sections are:  header = [len:2B][dest_id:1B][msg_id:1B][rep:1B][n_reps:1B]
                                         body   = [payload][CRC32 over header+payload: 4B]
      - fec = 0  : header + body sent uncoded (identical to the non-FEC framer)
        fec = 15 : Hamming(15,11)    fec = 31 : Hamming(31,26)
        Preamble, train word and sync word are never coded (the correlator / deframer look for them as raw bits).
        Header and body are two separate coded sections (the receiver decodes the header first to learn the length);
        the coded bits are bit-for-bit what the previous FEC framer produced, so a deframer written for that
        format still decodes them. Anything after the body is ignored by the receiver.
      - interleave = True: each section's codewords are sent column by column (burst-error protection)
      - The train word is known to the RX: the correlator finds it, tags it, and the equalizer trains on it.
        It must match TRAIN_BITS in the flowgraph.
      - Postamble: pads the frame to a whole number of Pluto sink buffers (buffer_size is in SAMPLES, so one
        buffer = buffer_size / samples_per_byte bytes) and is never shorter than one buffer. The TX pulse-shaping
        filter holds back ~86 samples and the sink holds back the last partial buffer; both fall inside the
        postamble, so no frame bits are lost or delayed.
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      # 31-bit m-sequence + 1 pad bit. MUST match TRAIN_BITS in the flowgraph (RX side).
      TRAIN_WORD = bytes([0xF8, 0xDD, 0x42, 0x58])


      def hamming_tables(n):
          """Standard positional Hamming layout: parity bits at positions 1, 2, 4, 8, (16)."""
          m = {15: 4, 31: 5}[n]
          pos = np.arange(1, n + 1)
          is_parity = (pos & (pos - 1)) == 0
          data_idx = np.flatnonzero(~is_parity)          # 0-based indices of data positions
          par_idx = np.flatnonzero(is_parity)            # 0-based indices of 1, 2, 4, 8, (16)
          P = ((pos[data_idx, None] >> np.arange(m)) & 1).astype(np.int32)   # k x m
          return data_idx, par_idx, P


      def hamming_encode_bits(bits, n, interleave):
          """bits: 0/1 array. Pads to a multiple of k, returns the coded bit array."""
          data_idx, par_idx, P = hamming_tables(n)
          k = len(data_idx)
          nblk = -(-len(bits) // k)
          d = np.zeros(nblk * k, dtype=np.int32)
          d[:len(bits)] = bits
          d = d.reshape(nblk, k)
          cw = np.zeros((nblk, n), dtype=np.uint8)
          cw[:, data_idx] = d
          cw[:, par_idx] = (d @ P) & 1
          return (cw.T if interleave else cw).reshape(-1)


      class PacketFramerTX(gr.basic_block):
          def __init__(self, peer_id=1, preamble_len=64, repeat_count=1, max_payload_len=1024,
                       preamble_byte=0xFF, buffer_size=2048, postamble_byte=0xFF, train_enable=1,
                       fec=15, interleave=1, samples_per_byte=32):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst, FEC)",
                  in_sig=None,
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.buffer_size = int(buffer_size)              # Pluto sink buffer, in SAMPLES
              self.postamble_byte = int(postamble_byte) & 0xFF
              self.train_enable = int(train_enable)
              self.fec = int(fec)
              self.interleave = bool(int(interleave))
              self.samples_per_byte = max(1, int(samples_per_byte))   # 8 bits * samples/symbol (BPSK)
              if self.fec not in (0, 15, 31):
                  raise ValueError("fec must be 0, 15 or 31")
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def _encode_section(self, data):
              bits = np.unpackbits(np.frombuffer(data, dtype=np.uint8))
              return hamming_encode_bits(bits, self.fec, self.interleave)

          def _coded_body(self, header, payload):
              """Everything after the sync word: header + payload + CRC, coded if fec != 0."""
              crc = zlib.crc32(header + payload).to_bytes(4, "big")
              if self.fec == 0:
                  return header + payload + crc
              coded = np.concatenate((self._encode_section(header),
                                      self._encode_section(payload + crc)))
              return np.packbits(coded).tobytes()               # pads the last byte with 0s

          def _postamble_len(self, raw_len):
              """Bytes of postamble: at least one sink buffer, and total a whole number of buffers."""
              if self.buffer_size <= 0:
                  return 0
              unit = max(1, -(-self.buffer_size // self.samples_per_byte))    # bytes per sink buffer
              need = raw_len + unit                                           # leave one full buffer of postamble
              return (-(-need // unit)) * unit - raw_len

          def build_frame(self, header, payload):
              preamble = bytes([self.preamble_byte]) * self.preamble_len
              train = TRAIN_WORD if self.train_enable else b""
              raw = preamble + train + SYNC_WORD + self._coded_body(header, payload)
              return raw + bytes([self.postamble_byte]) * self._postamble_len(len(raw))

          def handle_msg(self, msg):
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return

              if not payload:
                  return

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[: self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              fec_txt = "no FEC" if self.fec == 0 else f"Hamming({self.fec},{self.fec - (4 if self.fec == 15 else 5)})"
              print(
                  f"[TX] msg #{msg_id} (to peer {self.peer_id}): '{payload.decode('utf-8', 'replace')}' "
                  f"({n_reps} bursts queued, {fec_txt})",
                  flush=True,
              )

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([self.peer_id, msg_id, rep, n_reps])
                  frame = self.build_frame(header, payload)

                  # Build metadata dictionary with tx_sob and tx_eob tags
                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("tx_sob"), pmt.PMT_T)
                  meta = pmt.dict_add(meta, pmt.intern("tx_eob"), pmt.PMT_T)

                  # Explicit offset tags for downstream PDU-to-Tagged-Stream conversion
                  sob_tag = pmt.make_tuple(pmt.from_long(0), pmt.intern("tx_sob"), pmt.PMT_T)
                  eob_tag = pmt.make_tuple(pmt.from_long(len(frame) - 1), pmt.intern("tx_eob"), pmt.PMT_T)
                  extra_tags = pmt.list2(sob_tag, eob_tag)
                  meta = pmt.dict_add(meta, pmt.intern("extra_tags"), extra_tags)

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
    buffer_size: BUFFER_SIZE
    fec: FEC
    interleave: 'True'
    max_payload_len: max_payload_len
    peer_id: MY_ID
    postamble_byte: '0xFF'
    preamble_byte: '0xFF'
    preamble_len: '128'
    repeat_count: '1'
    samples_per_byte: 8*sps
    train_enable: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Test Traffic RX  (receive logger)

      Connect:  Packet Deframer RX  pdu_out  ->  pdu_in

      Every frame the deframer delivers is written to  <log_dir>/rx_<date>_<time>.csv  with a wall-clock
      timestamp (microseconds), the test run_id / seq when the payload carries the test header (A5 5A ...),
      the deframer's msg_id, and the payload as hex. Non-test frames (chat etc.) are logged with is_test = 0.
      One file per flowgraph start; rows are flushed immediately, so the log survives a crash or Ctrl-C.
      Prints a running count per test run (received, missing so far, delivery %).
      The deframer only delivers CRC-good frames, so this log holds correct packets only; losses are
      found by the analysis script from the gaps against the TX log.
      """
      import csv
      import datetime
      import os
      import socket
      import time

      import pmt
      from gnuradio import gr

      MAGIC = b"\xA5\x5A"
      RX_FIELDS = ["rx_time_us", "rx_time_iso", "is_test", "run_id", "seq", "size", "msg_id", "host", "payload_hex"]


      class TestTrafficRX(gr.basic_block):
          def __init__(self, log_dir="~/link_tests", verbose=1, print_every=10):
              gr.basic_block.__init__(self, name="Test Traffic RX", in_sig=None, out_sig=None)
              self.log_dir = str(log_dir)
              self.verbose = int(verbose)
              self.print_every = max(1, int(print_every))
              self._host = socket.gethostname()
              self._f = None
              self._w = None
              self._path = None
              self._runs = {}            # run_id -> {"seqs": set, "max": int, "dups": int}
              self._n_other = 0

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self._handle)

          # ---------------------------------------------------------------- file
          def start(self):
              self._open()
              return True

          def stop(self):
              self._summary()
              if self._f:
                  self._f.close()
                  self._f = None
              return True

          def _open(self):
              if self._f:
                  return
              d = os.path.expanduser(self.log_dir)
              os.makedirs(d, exist_ok=True)
              self._path = os.path.join(d, f"rx_{datetime.datetime.now():%Y%m%d_%H%M%S}.csv")
              self._f = open(self._path, "w", newline="")
              self._w = csv.writer(self._f)
              self._w.writerow(RX_FIELDS)
              self._f.flush()
              print(f"[TEST RX] logging received frames to {self._path}", flush=True)

          # ---------------------------------------------------------------- messages
          def _handle(self, msg):
              t_us = time.time_ns() // 1000
              meta = pmt.PMT_NIL
              try:
                  data = msg
                  if pmt.is_pair(msg):
                      meta, data = pmt.car(msg), pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      payload = bytes(pmt.u8vector_elements(data))
                  elif pmt.is_symbol(data):
                      payload = pmt.symbol_to_string(data).encode("utf-8")
                  else:
                      payload = str(pmt.to_python(data)).encode("utf-8")
              except Exception as e:
                  print(f"[TEST RX] could not parse message: {e!r}", flush=True)
                  return

              msg_id = -1
              try:
                  if pmt.is_dict(meta):
                      v = pmt.dict_ref(meta, pmt.intern("msg_id"), pmt.PMT_NIL)
                      if pmt.is_integer(v):
                          msg_id = pmt.to_long(v)
              except Exception:
                  pass

              is_test = len(payload) >= 8 and payload[:2] == MAGIC
              run_id = int.from_bytes(payload[2:4], "big") if is_test else -1
              seq = int.from_bytes(payload[4:8], "big") if is_test else -1

              self._open()
              self._w.writerow([t_us,
                                datetime.datetime.fromtimestamp(t_us / 1e6).isoformat(timespec="milliseconds"),
                                int(is_test), run_id, seq, len(payload), msg_id, self._host, payload.hex()])
              self._f.flush()

              if not is_test:
                  self._n_other += 1
                  return
              st = self._runs.setdefault(run_id, {"seqs": set(), "max": -1, "dups": 0})
              if seq in st["seqs"]:
                  st["dups"] += 1
              st["seqs"].add(seq)
              st["max"] = max(st["max"], seq)
              n = len(st["seqs"])
              if self.verbose and (n == 1 or n % self.print_every == 0):
                  expected = st["max"] + 1
                  print(f"[TEST RX] run {run_id:04x}: {n} received, last seq {seq}, {expected - n} missing so far "
                        f"({100.0 * n / expected:.1f}% of seq 0..{st['max']})", flush=True)

          def _summary(self):
              for run_id, st in self._runs.items():
                  n, expected = len(st["seqs"]), st["max"] + 1
                  print(f"[TEST RX] run {run_id:04x} total: {n} received of seq 0..{st['max']} "
                        f"({100.0 * n / max(expected, 1):.1f}%), {st['dups']} duplicates", flush=True)
              if self._n_other:
                  print(f"[TEST RX] {self._n_other} non-test frames logged", flush=True)
              if self._path:
                  print(f"[TEST RX] log: {self._path}", flush=True)
    log_dir: '"~/link_tests"'
    print_every: '10'
    verbose: '1'
  states: {state: disabled}
- name: epy_block_corr
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Training-word correlator (drop-in for digital_corr_est_cc)
      - Input : complex stream at 2 samples/symbol (symbol sync output)
      - Output: the same stream delayed by a fixed EVEN number of samples (so tags can be placed in the past
        without shifting the symbol / midpoint sample phase)
      - Slides the reference (TRAIN_REF) over the stream and computes the NORMALIZED correlation
            rho = |sum(conj(ref) * x)|^2 / (E_ref * E_window)      (0..1, independent of signal amplitude)
        Where rho has a local maximum above thr it adds a 'corr_est' tag (and 'corr_start') on the
        first training symbol, shifted by mark_delay samples. Random data gives rho ~ 0.1-0.25; a real
        training word gives ~0.8-1.0, so thr ~ 0.6-0.7 is a good start. The tag value is rho.
      - Pure numpy, bounds-checked: no use of GNU Radio's corr_est_cc.
      """
      import numpy as np
      import pmt
      from gnuradio import gr


      class TrainCorr(gr.sync_block):
          def __init__(self, ref=None, thr=0.7, mark_delay=0, verbose=1):
              gr.sync_block.__init__(
                  self,
                  name="Training-word Correlator",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64],
              )
              if ref is None:
                  ref = [1.0]
              self._ref = np.asarray(ref, dtype=np.complex64)
              self._L = len(self._ref)
              self._E = float(np.sum(np.abs(self._ref) ** 2))
              self.thr = float(thr)
              self.mark_delay = max(0, int(mark_delay))
              self.verbose = int(verbose)
              # Output delay: >= L + 3 so every peak is examined exactly once, and a MULTIPLE OF 2 (samples per
              # symbol) so the symbol-timed samples stay on even stream indices -- the linear equalizer takes
              # the first sample of every 2-sample block, so an odd delay would make it sample the midpoints.
              self._D = self._L + 8
              self._D += self._D % 2
              self.set_history(self._D + 1)
              self._next_p = 0               # first absolute input index not yet examined
              self._last_p = -10**12         # last tagged absolute input index
              self._seen = 0                 # samples since last status line
              self._best = 0.0               # strongest normalized correlation since last status line

          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              n_out = len(out)
              out[:] = x[:n_out]             # in[i] <-> absolute input index a-D+i  ==  output index a+i

              a = self.nitems_written(0)
              base = a - self._D             # absolute input index of x[0]
              if len(x) < self._L + 5:
                  return n_out
              c = np.correlate(x, self._ref, "valid")                  # window starting at x[n]
              w = np.convolve(np.abs(x).astype(np.float64) ** 2, np.ones(self._L), "valid")
              m = (np.abs(c).astype(np.float64) ** 2) / (self._E * w + 1e-12)    # normalized, 0..1
              self._best = max(self._best, float(m.max()))
              self._seen += n_out

              n0 = max(self._next_p - base, 2, -base)       # first window start to examine (p >= 0)
              n1 = len(m) - 3                               # last start with 2 neighbours on the right
              if n1 >= n0:
                  seg = m[n0 - 2 : n1 + 3]
                  mid = seg[2:-2]
                  thr_abs = self.thr
                  cond = (
                      (mid > thr_abs)
                      & (mid > seg[0:-4]) & (mid > seg[1:-3])
                      & (mid >= seg[3:-1]) & (mid >= seg[4:])
                  )
                  for j in np.flatnonzero(cond):
                      p = base + n0 + int(j)
                      if p - self._last_p < self._L:
                          continue
                      self._last_p = p
                      ratio = float(mid[j])
                      off = int(p + self._D + self.mark_delay)    # output index; always >= a
                      val = pmt.from_double(ratio)
                      self.add_item_tag(0, off, pmt.intern("corr_start"), val)
                      self.add_item_tag(0, off, pmt.intern("corr_est"), val)
                      self._best = 0.0
                      self._seen = 0
                      if self.verbose:
                          print(f"[CORR] train word found: correlation = {ratio:.2f} (thr {self.thr:.2f})", flush=True)
                  self._next_p = base + n1 + 1

              if self.verbose and self._seen > 400000:
                  if self._best > 0.35:
                      print(f"[CORR] no tag; strongest correlation in last window = {self._best:.2f} (thr {self.thr:.2f})", flush=True)
                  self._best = 0.0
                  self._seen = 0
              return n_out
    comment: Python replacement for digital_corr_est_cc (avoids its out-of-range read).
    mark_delay: train_delay
    ref: TRAIN_REF
    thr: corr_thr
    verbose: '1'
  states: {}
- name: epy_csma
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: CSMA/CA MAC  (carrier sense + slotted random backoff, single frequency)

      Wiring
        RX  : Pluto Source  -> in0 (this block) -> out0 -> Power Squelch -> ... (rest of the RX chain)
        TX  : Packet Framer TX pdu_out -> pdu_in (this block) ;  pdu_out -> PDU to Tagged Stream -> modulator -> Pluto Sink
        ctrl: optional messages "fail"/"collision" (double the contention window), "ok" (reset it), "flush" (empty the queue)

      Carrier sense (spike-proof)
        Every nfft samples the block takes an FFT and uses the MEDIAN power of the bins inside +/- cs_bw_hz/2
        (bins within dc_exclude_hz of 0 Hz are left out). A data burst raises every in-band bin, so the median
        rises; a narrow spike (LO leakage / carrier left after a burst) lifts one or two bins and does not move the
        median. The median is smoothed over sense_s and compared with a tracked noise floor:
            busy  when  cs > floor + cs_margin_db ;   idle again when  cs < floor + cs_margin_db - cs_hyst_db
        The floor is the floor_percentile of cs over the last floor_window_s (own transmissions excluded); it falls
        at once but rises at most floor_rise_db_s dB/s, so traffic cannot drag it up.

      Access (CSMA/CA, as in 802.11 DCF without ACKs)
        Before every frame: draw a backoff of 0 .. cw-1 slots. Slot boundaries are counted from the moment the
        channel went quiet: quiet start + difs_s, + slot_s, + 2*slot_s ... Each boundary reached while idle uses up
        one slot; the frame is released at the boundary where the count reaches zero. A busy channel freezes the
        count; after it, DIFS again and the count continues. Because both nodes anchor their boundaries on the same
        burst end, two frames only collide if they picked the same boundary. cw starts at cw_min; "fail" messages
        on ctrl double it up to cw_max, "ok" resets it (wire these from the ARQ layer if available).

      Own transmission (half duplex)
        After a release the block watches its own receiver for the echo of its own burst. Until the echo has ended
        (+ tail_s), or until echo_timeout_s + airtime + tail_s if no echo is seen, the channel is treated as ours:
        no sensing, no floor update, and (blank_rx = 1) the RX output is zeroed so the squelch / AGC / FLL /
        equalizer / deframer do not process our own burst. The delay between release and echo = TX + RX latency
        of the radios = the window in which both nodes can still collide; slot_s must be longer than it.
        The measured value is printed in the stats line.

      All timing runs on the RX sample clock (samples / samp_rate), not on the PC clock.
      Read-out for QT widgets (Function Probe): cs_db(), threshold_db(), floor_db(), is_busy(), queue_len()
      """
      import collections
      import threading

      import numpy as np
      import pmt
      from gnuradio import gr


      class CsmaMac(gr.sync_block):
          def __init__(self, samp_rate=1.5e6, samples_per_byte=32, slot_s=0.015, difs_s=0.020,
                       cw_min=8, cw_max=128, cs_margin_db=6.0, cs_hyst_db=2.0, cs_bw_hz=400e3,
                       dc_exclude_hz=10e3, nfft=256, sense_s=0.001, floor_window_s=2.0,
                       floor_percentile=10.0, floor_rise_db_s=1.0, echo_timeout_s=0.100, tail_s=0.002,
                       blank_rx=1, max_queue=64, max_defer_s=0.0, verbose=1, stats_every_s=10.0):
              gr.sync_block.__init__(self, name="CSMA/CA MAC", in_sig=[np.complex64], out_sig=[np.complex64])
              self.samp_rate = float(samp_rate)
              self.samples_per_byte = float(samples_per_byte)
              self.slot_s = float(slot_s)
              self.difs_s = float(difs_s)
              self.cw_min = max(1, int(cw_min))
              self.cw_max = max(self.cw_min, int(cw_max))
              self.cs_margin_db = float(cs_margin_db)
              self.cs_hyst_db = float(cs_hyst_db)
              self.floor_percentile = float(floor_percentile)
              self.floor_rise_db_s = float(floor_rise_db_s)
              self.echo_timeout_s = float(echo_timeout_s)
              self.tail_s = float(tail_s)
              self.blank_rx = int(blank_rx)
              self.max_queue = max(1, int(max_queue))
              self.max_defer_s = float(max_defer_s)
              self.verbose = int(verbose)
              self.stats_every_s = float(stats_every_s)

              # ---- carrier-sense front end
              self._nfft = int(nfft)
              self._dt = self._nfft / self.samp_rate                          # time per FFT block
              f = np.fft.fftfreq(self._nfft, 1.0 / self.samp_rate)
              sel = (np.abs(f) <= float(cs_bw_hz) / 2) & (np.abs(f) >= float(dc_exclude_hz))
              self._bins = np.flatnonzero(sel)
              if self._bins.size < 8:
                  raise ValueError("cs_bw_hz / dc_exclude_hz / nfft leave fewer than 8 bins to sense")
              self._win = np.hanning(self._nfft).astype(np.float32)
              # median of |X|^2 of white noise = ln2 * nfft * mean(w^2) * power  -> scale to "white-equivalent" power
              self._norm = 1.0 / (np.log(2.0) * self._nfft * float(np.mean(self._win ** 2)))
              self._smooth = collections.deque(maxlen=max(1, int(round(float(sense_s) / self._dt))))
              self._carry = np.zeros(0, np.complex64)
              self._cs_db = -200.0
              n_hist = max(64, int(float(floor_window_s) / self._dt))
              self._hist = collections.deque(maxlen=n_hist)
              self._floor_db = None
              self._floor_next = 0.0
              self._busy = True

              # ---- MAC state
              self._lock = threading.Lock()
              self._queue = collections.deque()
              self._cw = self.cw_min
              self._backoff = None
              self._idle_run = 0.0
              self._rng = np.random.default_rng()
              self._n_abs = 0                       # absolute input sample index of the next new sample
              self._t = 0.0                         # current time on the RX sample clock, s
              self._self_tx = False
              self._tx = {}

              # ---- statistics
              self._st = collections.Counter()
              self._echo_delays = collections.deque(maxlen=200)
              self._access_delays = collections.deque(maxlen=200)
              self._busy_time = 0.0
              self._stat_t0 = 0.0
              self._warned_no_echo = False

              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self._on_pdu)
              self.message_port_register_in(pmt.intern("ctrl"))
              self.set_msg_handler(pmt.intern("ctrl"), self._on_ctrl)
              self.message_port_register_out(pmt.intern("pdu_out"))

          # ------------------------------------------------------------------ read-outs (Function Probe)
          def cs_db(self):
              return float(self._cs_db)

          def floor_db(self):
              return float(self._floor_db) if self._floor_db is not None else -200.0

          def threshold_db(self):
              return self.floor_db() + self.cs_margin_db

          def is_busy(self):
              return int(self._busy or self._self_tx)

          def queue_len(self):
              return len(self._queue)

          # ------------------------------------------------------------------ messages
          def _on_pdu(self, msg):
              if not pmt.is_pair(msg) or not pmt.is_u8vector(pmt.cdr(msg)):
                  print("[CSMA] pdu_in expects a PDU (meta . u8vector) from the framer; message ignored", flush=True)
                  return
              with self._lock:
                  if len(self._queue) >= self.max_queue:
                      self._queue.popleft()
                      self._st["dropped"] += 1
                      print(f"[CSMA] queue full ({self.max_queue}): oldest frame dropped", flush=True)
                  self._queue.append((msg, self._t))

          def _on_ctrl(self, msg):
              try:
                  txt = str(pmt.to_python(pmt.car(msg) if pmt.is_pair(msg) else msg)).lower()
              except Exception:
                  txt = ""
              if "fail" in txt or "collision" in txt or "nack" in txt:
                  self._cw = min(self.cw_max, self._cw * 2)
              elif "ok" in txt or "success" in txt or "ack" in txt:
                  self._cw = self.cw_min
              elif "flush" in txt:
                  with self._lock:
                      self._queue.clear()

          # ------------------------------------------------------------------ carrier sense helpers
          def _update_floor(self):
              if len(self._hist) < self._hist.maxlen // 4:
                  return
              raw = float(np.percentile(np.fromiter(self._hist, float, len(self._hist)), self.floor_percentile))
              if self._floor_db is None or raw <= self._floor_db:
                  self._floor_db = raw
              else:
                  self._floor_db = min(raw, self._floor_db + self.floor_rise_db_s * 0.05)

          def _release(self):
              with self._lock:
                  if not self._queue:
                      return
                  msg, t_enq = self._queue.popleft()
              nbytes = pmt.length(pmt.cdr(msg))
              airtime = nbytes * self.samples_per_byte / self.samp_rate
              self.message_port_pub(pmt.intern("pdu_out"), msg)
              self._self_tx = True
              self._tx = {"t0": self._t, "air": airtime, "echo_t": None, "low_since": None,
                          "hard_end": self._t + self.echo_timeout_s + airtime + self.tail_s + 0.02}
              self._backoff, self._idle_run = None, 0.0
              self._st["tx"] += 1
              self._access_delays.append(self._t - t_enq)
              if self.verbose >= 2:
                  print(f"[CSMA] TX {nbytes} B frame ({airtime * 1e3:.1f} ms) after {1e3 * (self._t - t_enq):.1f} ms "
                        f"in queue, cw {self._cw}", flush=True)

          def _end_self_tx(self, reason):
              self._self_tx = False
              # the channel went quiet when our echo dropped (tail_s ago): count idle time from there, so our slot
              # grid lines up with the other node's, which saw the same burst end
              self._idle_run = self.tail_s if reason == "echo_end" else 0.0
              if reason == "timeout" and self._tx.get("echo_t") is None:
                  self._st["no_echo"] += 1
                  if not self._warned_no_echo:
                      self._warned_no_echo = True
                      print("[CSMA] own burst not seen on our receiver: RX blanking falls back to the timer "
                            "(echo_timeout_s + airtime). Check the TX, or raise echo_timeout_s.", flush=True)

          # ------------------------------------------------------------------ one sense step (nfft samples)
          def _step(self, cs_db):
              dt = self._dt
              thr_on = (self._floor_db if self._floor_db is not None else 1e9) + self.cs_margin_db
              loud = cs_db > thr_on

              if self._self_tx:                                   # our own burst: watch the echo, do not sense
                  tx = self._tx
                  if tx["echo_t"] is None:
                      if loud:
                          tx["echo_t"] = self._t
                          self._echo_delays.append(self._t - tx["t0"])
                      elif self._t - tx["t0"] > self.echo_timeout_s + tx["air"] + self.tail_s:
                          self._end_self_tx("timeout")
                          return
                  else:
                      if loud:
                          tx["low_since"] = None
                      elif tx["low_since"] is None:
                          tx["low_since"] = self._t
                      elif self._t - tx["low_since"] >= self.tail_s:
                          self._end_self_tx("echo_end")
                          return
                  if self._t >= tx["hard_end"]:
                      self._end_self_tx("timeout")
                  return

              # channel state with hysteresis (busy until the floor is known)
              self._hist.append(cs_db)
              if self._floor_db is None:
                  self._busy = True
              elif self._busy:
                  self._busy = cs_db > thr_on - self.cs_hyst_db
              else:
                  self._busy = loud
              if self._busy:
                  self._busy_time += dt

              with self._lock:
                  pending = len(self._queue)
                  t_head = self._queue[0][1] if pending else None
              if not pending:
                  self._idle_run = 0.0 if self._busy else self._idle_run + dt
                  return

              if self.max_defer_s > 0 and self._t - t_head > self.max_defer_s and self._floor_db is not None:
                  self._st["forced"] += 1
                  self._release()
                  return

              if self._backoff is None:                           # new frame at the head: draw its backoff
                  self._backoff = int(self._rng.integers(0, self._cw))

              if self._busy:
                  if self._idle_run > 0.0:
                      self._st["deferrals"] += 1
                  self._idle_run = 0.0                            # countdown frozen; DIFS again after the busy period
                  return

              # Slot boundaries sit at idle_start + difs + m * slot (m = 0, 1, 2 ...). Both nodes see the same burst end,
              # so their boundaries coincide and only frames released at the SAME boundary can collide.
              p_prev = self._idle_run - self.difs_s
              self._idle_run += dt
              p_now = self._idle_run - self.difs_s
              if p_now < 0:
                  return
              crossings = int(np.floor(p_now / self.slot_s)) - int(np.floor(p_prev / self.slot_s))
              for _ in range(crossings):
                  if self._backoff == 0:
                      self._release()
                      return
                  self._backoff -= 1

          # ------------------------------------------------------------------ stream
          def work(self, input_items, output_items):
              x = input_items[0]
              out = output_items[0]
              n = len(x)
              out[:] = x

              first_abs = self._n_abs - len(self._carry)           # absolute index of buf[0]
              buf = np.concatenate((self._carry, x)) if len(self._carry) else x
              nb = len(buf) // self._nfft
              blank = []                                           # (start, stop) absolute sample ranges
              if nb:
                  blocks = buf[:nb * self._nfft].reshape(nb, self._nfft) * self._win
                  p = np.abs(np.fft.fft(blocks, axis=1)[:, self._bins]) ** 2
                  med = np.median(p, axis=1) * self._norm
                  for i in range(nb):
                      self._smooth.append(float(med[i]))                 # sliding mean over sense_s
                      self._cs_db = 10.0 * np.log10(max(sum(self._smooth) / len(self._smooth), 1e-20))
                      self._t = (first_abs + (i + 1) * self._nfft) / self.samp_rate
                      was_tx = self._self_tx
                      self._step(self._cs_db)
                      if self.blank_rx and (was_tx or self._self_tx):
                          s = first_abs + i * self._nfft
                          blank.append((s, s + self._nfft))
                      if self._t >= self._floor_next:
                          self._floor_next = self._t + 0.05
                          self._update_floor()
              self._carry = buf[nb * self._nfft:].copy()
              self._n_abs += n

              if self.blank_rx and self._self_tx:                  # samples not yet sensed, but already ours
                  blank.append((self._n_abs - len(self._carry), self._n_abs))
              x0 = self._n_abs - n
              for s, e in blank:
                  a, b = max(s, x0) - x0, min(e, self._n_abs) - x0
                  if b > a:
                      out[a:b] = 0

              if self.verbose and self.stats_every_s > 0 and self._t - self._stat_t0 >= self.stats_every_s:
                  self._print_stats()
              return n

          def _print_stats(self):
              span = max(1e-9, self._t - self._stat_t0)
              ed = list(self._echo_delays)
              ad = list(self._access_delays)
              echo = (f"own echo after {1e3 * np.median(ed):.1f} ms (max {1e3 * max(ed):.1f}) -> keep slot_s above it"
                      if ed else "own echo not measured yet")
              floor = f"{self._floor_db:.1f}" if self._floor_db is not None else "learning"
              print(f"[CSMA] floor {floor} dB, threshold +{self.cs_margin_db:g} dB, now {self._cs_db:.1f} dB, "
                    f"busy {100 * self._busy_time / span:.1f} % | tx {self._st['tx']}, deferrals {self._st['deferrals']}, "
                    f"queue {len(self._queue)}, cw {self._cw}, dropped {self._st['dropped']}, forced {self._st['forced']}, "
                    f"no-echo {self._st['no_echo']} | access delay median "
                    f"{(1e3 * np.median(ad)) if ad else 0:.0f} ms | {echo}", flush=True)
              self._stat_t0 = self._t
              self._busy_time = 0.0
    blank_rx: '1'
    comment: 'CSMA/CA: RX samples in -> blanked RX out (own bursts zeroed); framer PDUs in -> released PDUs out'
    cs_bw_hz: 400e3
    cs_hyst_db: '2.0'
    cs_margin_db: cs_margin
    cw_max: '128'
    cw_min: '8'
    dc_exclude_hz: 10e3
    difs_s: '0.020'
    echo_timeout_s: '0.100'
    floor_percentile: '10.0'
    floor_rise_db_s: '1.0'
    floor_window_s: '2.0'
    max_defer_s: '0.0'
    max_queue: '64'
    nfft: '256'
    samp_rate: samp_rate
    samples_per_byte: 8*sps
    sense_s: '0.001'
    slot_s: '0.015'
    stats_every_s: '10.0'
    tail_s: '0.002'
    verbose: '1'
  states: {}
- name: epy_noise
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Noise-floor tracker -> automatic squelch threshold
      - Sink block: connect it to the SDR source output (BEFORE any squelch/AGC).
      - Splits the stream into short slices (default ~1 ms), keeps the mean power of each slice for the
        last `window_s` seconds, and takes a low percentile of them as the noise floor (bursts only occupy
        the top of the distribution, so they are ignored as long as the channel is idle > `percentile` % of the time).
      - level() returns the squelch threshold in dB:  noise floor (dB) + margin_db, clamped to
        [thr_min, thr_max]. The estimate falls immediately but rises at most `rise_db_s` dB per second, so a
        long burst or a back-to-back transmission cannot drag the threshold up and close the squelch.
      - Use with a "Function Probe" variable named power_threshold:  block id = this block, function = level,
        poll rate ~ 5 Hz. The Pluto/squelch power unit is the same: dB of mean |x|^2.
      """
      import threading
      import time
      from collections import deque

      import numpy as np
      from gnuradio import gr


      class NoiseFloor(gr.sync_block):
          def __init__(self, samp_rate=1.5e6, margin_db=6.0, window_s=1.0, percentile=10.0,
                       rise_db_s=1.0, thr_min=-100.0, thr_max=-20.0, init_db=-40.0, verbose=1):
              gr.sync_block.__init__(self, name="Noise Floor Tracker", in_sig=[np.complex64], out_sig=None)
              self.samp_rate = float(samp_rate)
              self.margin_db = float(margin_db)
              self.window_s = float(window_s)
              self.percentile = float(percentile)
              self.rise_db_s = float(rise_db_s)
              self.thr_min = float(thr_min)
              self.thr_max = float(thr_max)
              self.init_db = float(init_db)
              self.verbose = int(verbose)

              self._slice = max(64, int(self.samp_rate * 1e-3))            # ~1 ms
              n_slices = max(16, int(self.window_s * self.samp_rate / self._slice))
              self._ring = deque(maxlen=n_slices)
              self._min_slices = max(8, n_slices // 4)                       # wait for 1/4 window before trusting
              self._carry = np.zeros(0, np.float32)
              self._lock = threading.Lock()
              self._est_db = None
              self._t_last = None
              self._out = self.init_db
              self._printed = None

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              if n == 0:
                  return 0
              p = x.real.astype(np.float32) ** 2 + x.imag.astype(np.float32) ** 2
              if self._carry.size:
                  p = np.concatenate((self._carry, p))
              k = len(p) // self._slice
              if k:
                  means = p[: k * self._slice].reshape(k, self._slice).mean(axis=1, dtype=np.float64)
                  with self._lock:
                      self._ring.extend(means)
              self._carry = p[k * self._slice:]
              return n

          def noise_db(self):
              return self._est_db

          def level(self):
              """Called by the Function Probe variable: returns the squelch threshold in dB."""
              with self._lock:
                  arr = np.fromiter(self._ring, dtype=np.float64, count=len(self._ring))
              if arr.size < self._min_slices:
                  return self._out
              raw_db = 10.0 * np.log10(max(float(np.percentile(arr, self.percentile)), 1e-20))
              now = time.monotonic()
              if self._est_db is None:
                  self._est_db = raw_db
              else:
                  dt = max(0.0, now - self._t_last)
                  if raw_db <= self._est_db:
                      self._est_db = raw_db
                  else:
                      self._est_db = min(raw_db, self._est_db + self.rise_db_s * dt)
              self._t_last = now
              self._out = float(min(self.thr_max, max(self.thr_min, self._est_db + self.margin_db)))
              if self.verbose and (self._printed is None or abs(self._out - self._printed) >= 1.0):
                  print(f"[SQL] noise floor {self._est_db:.1f} dB -> squelch threshold {self._out:.1f} dB", flush=True)
                  self._printed = self._out
              return self._out
    init_db: '-40.0'
    margin_db: margin_db
    percentile: '10.0'
    rise_db_s: '1.0'
    samp_rate: samp_rate
    thr_max: '-20.0'
    thr_min: '-100.0'
    verbose: '1'
    window_s: '1.0'
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: FILTER_BW
    buffer_size: BUFFER_SIZE
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: TX_FREQ
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: FILTER_BW
    bbdc: 'True'
    buffer_size: BUFFER_SIZE
    filter_source: '''Auto'''
    frequency: RX_FREQ
    gain1: '''manual'''
    len_tag_key: '''packet_len'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'v6.0: single frequency (FREQ) + CSMA/CA (epy_csma). RX: source -> DC blocker (bypassed) -> CSMA (blanks own bursts) -> squelch. TX: framer -> CSMA -> PDU to stream.'
  states: {}
- name: note_1
  id: note
  parameters:
    note: To observe signal power
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0'
    ymin: '-55'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.01'
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', analog_pwr_squelch_xx_0, '0']
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', blocks_copy_1_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', analog_agc_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_1, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_0_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_5_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', virtual_sink_5_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [dc_blocker_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [dc_blocker_xx_0, '0', blocks_copy_1_1, '0']
- [dc_blocker_xx_0, '0', epy_csma, '0']
- [dc_blocker_xx_0, '0', epy_noise, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_corr, '0']
- [epy_block_0, msg_out, epy_block_0_0_1, msg_in]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0_0, pdu_out, epy_block_1, pdu_in]
- [epy_block_0_0_1, pdu_out, epy_csma, pdu_in]
- [epy_block_corr, '0', blocks_tag_debug_corr, '0']
- [epy_block_corr, '0', digital_linear_equalizer_0, '0']
- [epy_csma, '0', analog_pwr_squelch_xx_0_0, '0']
- [epy_csma, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [iio_pluto_source_0, '0', dc_blocker_xx_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0, msg_in]
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0_1, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_nlog10_ff_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', blocks_copy_0_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
