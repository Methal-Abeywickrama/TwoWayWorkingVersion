options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    modulus: '2'
    step_size: '.01'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.0314'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-2'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: QPSK_CONST.arity()
    w: costas_bw
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 2* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {state: disabled}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '15'
    sps: '2'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '1.5'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Burst Packet Framer TX
      - Outputs packed byte PDUs directly to pdu_pdu_to_tagged_stream
      - Zero idle transmission (idle between bursts = complete silence)
      - Zero postamble / trailing idle
      - Frame layout: [preamble] [1A CF FC 1D] [len: 2B][msg_id: 1B][rep: 1B][n_reps: 1B] [payload] [CRC32: 4B]
      - CRC32 covers header + payload
      """
      import zlib
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])


      class PacketFramerTX(gr.basic_block):
          def __init__(self, preamble_len=64, repeat_count=5, max_payload_len=1024, preamble_byte=0xFF):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst)",
                  in_sig=None,
                  out_sig=None,
              )
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def handle_msg(self, msg):
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return

              if not payload:
                  return

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[:self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              preamble = bytes([self.preamble_byte]) * self.preamble_len
              print(f"[TX] msg #{msg_id}: '{payload.decode('utf-8', 'replace')}' ({n_reps} bursts queued)", flush=True)

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([msg_id, rep, n_reps])
                  crc = zlib.crc32(header + payload).to_bytes(4, "big")
                  frame = preamble + SYNC_WORD + header + payload + crc

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(pmt.PMT_NIL, vec))
    max_payload_len: '8196'
    preamble_byte: '0xFF'
    preamble_len: '350'
    repeat_count: '50'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: PacketDeframerRX
      """
      import numpy as np
      from gnuradio import gr
      import zlib

      class PacketDeframerRX(gr.sync_block):
          STATE_SYNC = 0
          STATE_HEADER = 1
          STATE_PAYLOAD_CRC = 2

          def __init__(self, max_bit_errors=1, max_payload_len=512):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX",
                  in_sig=[np.uint8],
                  out_sig=None
              )
              self.max_bit_errors = max_bit_errors
              self.max_payload_len = max_payload_len
              self.sync_target = 0x1ACFFC1D  # Matches TX sync word

              self.state = self.STATE_SYNC
              self.shift_reg = 0
              self.bit_buf = 0
              self.bit_count = 0
              self.byte_buf = bytearray()
              self.payload_len = 0
              self.target_bytes = 0

          def work(self, input_items, output_items):
              in_bits = input_items[0]

              for bit in in_bits:
                  b = int(bit) & 1

                  if self.state == self.STATE_SYNC:
                      self.shift_reg = ((self.shift_reg << 1) | b) & 0xFFFFFFFF
                      xor_diff = self.shift_reg ^ self.sync_target
                      
                      # Check for sync match (allowing bit errors over RF)
                      if bin(xor_diff).count('1') <= self.max_bit_errors:
                          self.state = self.STATE_HEADER
                          self.bit_buf = 0
                          self.bit_count = 0
                          self.byte_buf = bytearray()
                          self.target_bytes = 2

                  elif self.state == self.STATE_HEADER:
                      self.bit_buf = (self.bit_buf << 1) | b
                      self.bit_count += 1
                      if self.bit_count == 8:
                          self.byte_buf.append(self.bit_buf)
                          self.bit_buf = 0
                          self.bit_count = 0
                          if len(self.byte_buf) == self.target_bytes:
                              self.payload_len = int.from_bytes(self.byte_buf, 'big')
                              if 0 < self.payload_len <= self.max_payload_len:
                                  self.state = self.STATE_PAYLOAD_CRC
                                  self.byte_buf = bytearray()
                                  self.target_bytes = self.payload_len + 4  # payload + 4 CRC bytes
                              else:
                                  # False trigger / corrupted header
                                  self.state = self.STATE_SYNC

                  elif self.state == self.STATE_PAYLOAD_CRC:
                      self.bit_buf = (self.bit_buf << 1) | b
                      self.bit_count += 1
                      if self.bit_count == 8:
                          self.byte_buf.append(self.bit_buf)
                          self.bit_buf = 0
                          self.bit_count = 0
                          if len(self.byte_buf) == self.target_bytes:
                              payload = bytes(self.byte_buf[:self.payload_len])
                              rx_crc = int.from_bytes(self.byte_buf[self.payload_len:], 'big')
                              calc_crc = zlib.crc32(payload)

                              if rx_crc == calc_crc:
                                  msg_str = payload.decode('utf-8', errors='replace')
                                  print(f"\n========================================", flush=True)
                                  print(f"[RX RECEIVED]: {msg_str}", flush=True)
                                  print(f"========================================\n", flush=True)
                              else:
                                  print(f"[RX CRC ERROR] Expected: {calc_crc:#010x}, Received: {rx_crc:#010x}", flush=True)

                              self.state = self.STATE_SYNC
                              self.shift_reg = 0

              return len(in_bits)
    max_bit_errors: '1'
    max_payload_len: '4096'
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: '20000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: int(SDR_CF)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {state: disabled}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {state: disabled}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0, '0']
- [blocks_copy_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0, '0', iio_pluto_sink_0, '0']
- [blocks_tag_gate_0, '0', virtual_sink_5, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_tag_gate_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_tag_gate_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_0_0, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0, '0', blocks_copy_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
