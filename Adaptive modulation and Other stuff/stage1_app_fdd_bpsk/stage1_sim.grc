options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever_sim
    output_language: python
    title: 'CDP transceiver - Stage 1 (app + FDD radio, BPSK) (SIM: ZMQ IQ, no radio)'
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    comment: SDR URI (env TL_SDR_URI)
    value: os.environ.get('TL_SDR_URI', 'ip:192.168.1.10')
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: MY_ID
  id: variable
  parameters:
    value: tl_local_addr
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: TX_FREQ_A
  id: variable
  parameters:
    value: 2412e6
  states: {}
- name: TX_FREQ_B
  id: variable
  parameters:
    value: 2437e6
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    modulus: '4'
    step_size: '.01'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: fdd_side
  id: variable
  parameters:
    comment: |-
      FDD: side A transmits on TX_FREQ_A and
      listens on TX_FREQ_B; side B the reverse.
      Default: lower address = A.
    value: os.environ.get('TL_FDD_SIDE', 'A' if tl_local_addr < tl_peer_addr else 'B')
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: iq_rx_port
  id: variable
  parameters:
    value: 53002 if fdd_side == 'A' else 53001
  states: {}
- name: iq_tx_port
  id: variable
  parameters:
    comment: 'SIM only: ZMQ IQ ports replacing the radio'
    value: 53001 if fdd_side == 'A' else 53002
  states: {}
- name: nv
  id: variable_qtgui_range
  parameters:
    comment: |-
      Extra noise added after the AGC
      (0 = off). Use it to test the link.
    label: RX extra noise (nv)
    start: '0'
    step: '0.01'
    stop: '1'
    value: float(os.environ.get('TL_NOISE', '0'))
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: TX_FREQ_B if fdd_side == 'A' else TX_FREQ_A
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.020'
  states: {}
- name: tl_local_addr
  id: variable
  parameters:
    value: int(os.environ.get('TL_LOCAL_ADDR', '1'))
  states: {}
- name: tl_local_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_LOCAL_PORT', '1'))
  states: {}
- name: tl_m
  id: variable
  parameters:
    value: int(os.environ.get('TL_M', '4'))
  states: {}
- name: tl_max_retries
  id: variable
  parameters:
    value: int(os.environ.get('TL_MAX_RETRIES', '10'))
  states: {}
- name: tl_mtu
  id: variable
  parameters:
    value: int(os.environ.get('TL_MTU', '200'))
  states: {}
- name: tl_peer_addr
  id: variable
  parameters:
    value: int(os.environ.get('TL_PEER_ADDR', '2'))
  states: {}
- name: tl_role
  id: variable
  parameters:
    value: os.environ.get('TL_ROLE', 'initiator')
  states: {}
- name: tl_rto_ms
  id: variable
  parameters:
    value: int(os.environ.get('TL_RTO_MS', '500'))
  states: {}
- name: tl_zmq_rx_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_ZMQ_RX_PORT', '52002'))
  states: {}
- name: tl_zmq_tx_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_ZMQ_TX_PORT', '52001'))
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: TX_FREQ_A if fdd_side == 'A' else TX_FREQ_B
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Test noise (nv slider). Pass-through at nv = 0.
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: nv
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '15'
    sps: '2'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '0.05'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import struct, pmt
      from gnuradio import gr

      HDR_FMT  = ">BBBBBBHHQ"
      HDR_SIZE = struct.calcsize(HDR_FMT)  # 18

      PKT_STR   = {0x01:"SYN", 0x02:"SYN_ACK", 0x03:"DATA",
                   0x04:"ACK", 0x05:"FIN", 0x06:"FIN_ACK"}
      MEDIA_STR = {0x01:"text", 0x02:"image", 0x03:"audio"}


      class blk(gr.sync_block):
          """Block 1: RX Header Parser -- stateless 18-byte binary header deserializer."""

          def __init__(self):
              gr.sync_block.__init__(self, name='RX Header Parser',
                                     in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg): return
              in_meta = pmt.car(msg)
              in_data = pmt.cdr(msg)
              if not pmt.is_u8vector(in_data): return
              raw = bytes(pmt.u8vector_elements(in_data))
              if len(raw) < HDR_SIZE: return
              fields   = struct.unpack_from(HDR_FMT, raw)
              pkt_type = fields[0]
              if not (0x01 <= pkt_type <= 0x06): return
              meta = in_meta if pmt.is_dict(in_meta) else pmt.make_dict()
              for k, v in [
                  ("pkt_type",     pmt.intern(PKT_STR.get(pkt_type, "UNKNOWN"))),
                  ("pkt_type_raw", pmt.from_uint64(pkt_type)),
                  ("media_type",   pmt.intern(MEDIA_STR.get(fields[1], "unknown"))),
                  ("src_addr",     pmt.from_uint64(fields[2])),
                  ("src_port",     pmt.from_uint64(fields[3])),
                  ("dst_addr",     pmt.from_uint64(fields[4])),
                  ("dst_port",     pmt.from_uint64(fields[5])),
                  ("seq_no",       pmt.from_uint64(fields[6])),
                  ("total_pkts",   pmt.from_uint64(fields[7])),
                  ("session_id",   pmt.from_uint64(fields[8])),
              ]:
                  meta = pmt.dict_add(meta, pmt.intern(k), v)
              payload  = raw[HDR_SIZE:]
              out_data = pmt.init_u8vector(len(payload), list(payload))
              self.message_port_pub(pmt.intern("pdus"), pmt.cons(meta, out_data))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 1: RX Header Parser'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Burst Packet Framer TX
      - Outputs packed byte PDUs directly to pdu_pdu_to_tagged_stream
      - Zero idle transmission (idle between bursts = complete silence)
      - Postamble: postamble_len zero bytes after the CRC, so the last real bytes are
        pushed out of the Pluto sink buffer / RX filters (deframer ignores them)
      - Frame layout: [preamble] [1A CF FC 1D] [len: 2B][dest_id: 1B][msg_id: 1B][rep: 1B][n_reps: 1B] [payload] [CRC32: 4B]
      - CRC32 covers header + payload
      - dest_id = the PDU's 'dst_addr' metadata (set by the SR-ARQ FSM), so frames go to the
        transport-layer destination; falls back to the peer_id parameter when there is none
      """
      import zlib
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])


      class PacketFramerTX(gr.basic_block):
          def __init__(self, peer_id=1, preamble_len=64, repeat_count=5, max_payload_len=1024, preamble_byte=0xFF,
                       postamble_len=160):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst)",
                  in_sig=None,
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.postamble_len = max(0, int(postamble_len))
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def _dest_of(self, msg):
              """Link destination: the PDU's dst_addr metadata if present, else peer_id."""
              if pmt.is_pair(msg) and pmt.is_dict(pmt.car(msg)):
                  key = pmt.intern("dst_addr")
                  if pmt.dict_has_key(pmt.car(msg), key):
                      v = pmt.dict_ref(pmt.car(msg), key, pmt.PMT_NIL)
                      try:
                          return int(pmt.to_uint64(v)) & 0xFF
                      except Exception:
                          try:
                              return int(pmt.to_long(v)) & 0xFF
                          except Exception:
                              pass
              return self.peer_id

          def handle_msg(self, msg):
              dest = self._dest_of(msg)
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return

              if not payload:
                  return

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[:self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              preamble = bytes([self.preamble_byte]) * self.preamble_len
              print(f"[TX] msg #{msg_id} (to peer {dest}): {len(payload)} B payload ({n_reps} bursts queued)", flush=True)

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([dest, msg_id, rep, n_reps])
                  crc = zlib.crc32(header + payload).to_bytes(4, "big")
                  frame = preamble + SYNC_WORD + header + payload + crc + bytes(self.postamble_len)

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(pmt.PMT_NIL, vec))
    comment: 'STAGE 1: link dest_id = FSM dst_addr'
    max_payload_len: '8192'
    peer_id: tl_peer_addr
    postamble_len: '160'
    preamble_byte: '0xFF'
    preamble_len: '1024'
    repeat_count: '1'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Fast Burst Packet Deframer RX
      - Vectorized NumPy sliding-window sync detection (fast C execution, minimal GIL load)
      - Positive correlation search only (180-deg phase ambiguity resolved upstream by diff decoder)
      - 1-bit false sync backtracking (prevents dropped frames on noise triggers)
      - Full CRC32 verification over header + payload
      - Destination address filtering: keeps frames where dest_id == peer_id (this node) or 0 (broadcast)
      - Message deduplication: displays payload once per msg_id, then logs burst statistics
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      HDR_BYTES = 6  # len (2B) + dest_id (1B) + msg_id (1B) + rep (1B) + n_reps (1B)


      class PacketDeframerRX(gr.sync_block):
          def __init__(self, peer_id=1, max_bit_errors=2, max_payload_len=1024, bit_rate=375000):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX (Fast Burst)",
                  in_sig=[np.uint8],
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.bit_rate = float(bit_rate)

              # Bipolar template (+1 / -1) for correlation
              self._sync = np.unpackbits(np.frombuffer(SYNC_WORD, np.uint8)).astype(np.int16) * 2 - 1
              self._buf = np.zeros(0, dtype=np.uint8)

              self.n_sync = 0
              self.n_ok = 0
              self.n_crc_fail = 0
              self.n_bad_len = 0

              self._bits_total = 0
              self._bits_at_last_ok = 0
              self._cur_id = None
              self._cur_reps = set()
              self._cur_nreps = 0

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("text_out"))

          def _flush_summary(self):
              if self._cur_id is not None:
                  got, n = len(self._cur_reps), self._cur_nreps
                  loss = 100.0 * (n - got) / max(n, 1)
                  print(f"[RX] msg #{self._cur_id}: {got}/{n} bursts OK (Loss: {loss:.0f}%)", flush=True)
              self._cur_id = None
              self._cur_reps = set()

          def _deliver(self, header, payload):
              dest_id, msg_id, rep, n_reps = header[2], header[3], header[4], header[5]
              if msg_id != self._cur_id:
                  self._flush_summary()
                  self._cur_id, self._cur_nreps = msg_id, n_reps
                  text = payload.decode("utf-8", errors="replace")
                  print("\n" + "=" * 40, flush=True)
                  print(f"[RX RECEIVED] #{msg_id}: {text}", flush=True)
                  print("=" * 40 + "\n", flush=True)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dest_id))
                  meta = pmt.dict_add(meta, pmt.intern("msg_id"), pmt.from_long(msg_id))
                  meta = pmt.dict_add(meta, pmt.intern("n_reps"), pmt.from_long(n_reps))
                  vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
                  self.message_port_pub(pmt.intern("text_out"), pmt.intern(text))

              self._cur_reps.add(rep)
              self._bits_at_last_ok = self._bits_total

          def work(self, input_items, output_items):
              bits = input_items[0] & 1
              self._bits_total += len(bits)
              self._buf = np.concatenate((self._buf, bits)) if len(self._buf) else bits.copy()

              # Flush transmission stats once channel has been quiet for > 0.5s of air time
              if self._cur_id is not None and self._bits_total - self._bits_at_last_ok > 0.5 * self.bit_rate:
                  self._flush_summary()

              thr = 32 - 2 * self.max_bit_errors
              hdr_bits = 32 + HDR_BYTES * 8

              while True:
                  buf = self._buf
                  if len(buf) < hdr_bits:
                      return len(bits)

                  # Fast matrix dot product over 32-bit window (only positive peaks)
                  pm = buf.astype(np.int16) * 2 - 1
                  corr = np.lib.stride_tricks.sliding_window_view(pm, 32) @ self._sync
                  cand = np.flatnonzero(corr >= thr)

                  if cand.size == 0:
                      self._buf = buf[-31:].copy()  # Preserve trailing bits that might begin a sync word
                      return len(bits)

                  i = int(cand[0])

                  if len(buf) < i + hdr_bits:
                      self._buf = buf[i:].copy()  # Await complete header bits
                      return len(bits)

                  header = np.packbits(buf[i + 32 : i + hdr_bits]).tobytes()
                  length = int.from_bytes(header[:2], "big")

                  if length == 0 or length > self.max_payload_len:
                      self.n_bad_len += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync
                      continue

                  end = i + 32 + (HDR_BYTES + length + 4) * 8
                  if len(buf) < end:
                      self._buf = buf[i:].copy()  # Await complete frame body bits
                      return len(bits)

                  body = np.packbits(buf[i + 32 : end]).tobytes()
                  hdr, payload, rx_crc = body[:HDR_BYTES], body[HDR_BYTES : HDR_BYTES + length], body[-4:]
                  self.n_sync += 1

                  if zlib.crc32(hdr + payload) == int.from_bytes(rx_crc, "big"):
                      dest_id = hdr[2]
                      if dest_id == self.peer_id or dest_id == 0:
                          self.n_ok += 1
                          self._deliver(hdr, payload)
                      # Frame addressed to another peer: discard silently
                      self._buf = buf[end:].copy()  # Advance past valid frame
                  else:
                      self.n_crc_fail += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync

              return len(bits)
    bit_rate: '375000'
    comment: |-
      STAGE 1: max_bit_errors 1 (was tl_peer_addr);
      accepts own addr or broadcast 0
    max_bit_errors: '1'
    max_payload_len: '8192'
    peer_id: MY_ID
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      # SR-ARQ FSM Core - patched: fixes A-E from INTEGRATION_NOTES.md (control timer slot,
      # post-session re-ACK, RX inactivity timeout, DATA retry cap, tx_done/tx_failed/tx_busy events)
      import os, struct, threading
      import pmt
      from gnuradio import gr

      PKT_SYN=0x01; PKT_SYN_ACK=0x02; PKT_DATA=0x03
      PKT_ACK=0x04; PKT_FIN=0x05; PKT_FIN_ACK=0x06
      MEDIA_CODE = {"text":0x01, "image":0x02, "audio":0x03}
      MEDIA_STR  = {0x01:"text", 0x02:"image", 0x03:"audio"}
      PKT_CODE   = {"SYN":PKT_SYN, "SYN_ACK":PKT_SYN_ACK, "DATA":PKT_DATA,
                    "ACK":PKT_ACK, "FIN":PKT_FIN, "FIN_ACK":PKT_FIN_ACK}
      PKT_STR    = {v:k for k,v in PKT_CODE.items()}
      IDLE="IDLE"; SYN_SENT="SYN_SENT"; SYN_RCVD="SYN_RCVD"
      TX_ACTIVE="TX_ACTIVE"; RX_ACTIVE="RX_ACTIVE"; FIN_SENT="FIN_SENT"


      class blk(gr.sync_block):
          """
          Block 2: SR-ARQ FSM Core
          Env vars: TL_M, TL_RTO_MS, TL_ROLE, TL_MTU, TL_LOCAL_ADDR,
                    TL_LOCAL_PORT, TL_MAX_RETRIES
          """

          def __init__(self,
                       m=int(os.environ.get('TL_M', '4')),
                       rto_ms=int(os.environ.get('TL_RTO_MS', '500')),
                       node_role=os.environ.get('TL_ROLE', 'initiator'),
                       mtu_bytes=int(os.environ.get('TL_MTU', '200')),
                       local_addr=int(os.environ.get('TL_LOCAL_ADDR', '0')),
                       local_port=int(os.environ.get('TL_LOCAL_PORT', '0')),
                       max_retries=int(os.environ.get('TL_MAX_RETRIES', '10'))):
              gr.sync_block.__init__(self, name="SR-ARQ FSM Core",
                                     in_sig=None, out_sig=None)
              assert node_role in ("initiator", "responder"), "TL_ROLE must be initiator or responder"
              assert 1 <= m <= 8,   "TL_M must be 1..8"
              assert mtu_bytes > 0, "TL_MTU must be > 0"
              self.m           = m
              self.seq_space   = 1 << m
              self.win_size    = 1 << (m - 1)
              self.rto_s       = rto_ms / 1000.0
              self.role        = node_role
              self.mtu         = mtu_bytes
              self.local_addr  = local_addr & 0xFF
              self.local_port  = local_port & 0xFF
              self.max_retries = max_retries
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("app_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("app_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu_in)
              self.set_msg_handler(pmt.intern("app_in"), self.handle_app_in)
              self._lock   = threading.Lock()
              self._timers = [None] * (self.seq_space + 1)
              self.last_done_sid = None
              self._reset_state()

          def _reset_state(self):
              self._cancel_all_timers()
              self.state = IDLE; self.session_id = 0
              self.dst_addr = 0; self.dst_port = 0
              self.ctrl_retries = 0; self.media_code = 0x00
              self.all_tx_pkts  = []
              self.tx_buf   = [None]  * self.seq_space
              self.acked    = [False] * self.seq_space
              self.data_retries = [0] * self.seq_space
              self.send_base = 0; self.next_seq_abs = 0; self.total_tx = 0
              self.rx_buf         = [None]  * self.seq_space
              self.received       = [False] * self.seq_space
              self.rcv_base = 0; self.total_rx = 0
              self.pkts_delivered = 0; self.reassembled = bytearray()

          def _start_timer(self, slot, timeout=None):
              self._cancel_timer(slot)
              t = threading.Timer(timeout or self.rto_s, self._on_timeout, args=[slot])
              t.daemon = True; self._timers[slot] = t; t.start()

          def _cancel_timer(self, slot):
              if self._timers[slot]:
                  self._timers[slot].cancel(); self._timers[slot] = None

          def _cancel_all_timers(self):
              if not hasattr(self, "_timers"): return
              for i in range(len(self._timers)): self._cancel_timer(i)

          def _on_timeout(self, slot):
              ctrl = self.seq_space
              with self._lock:
                  if slot == ctrl:
                      if self.state == SYN_SENT:
                          self.ctrl_retries += 1
                          if self.ctrl_retries > self.max_retries:
                              gr.log.error("FSM: SYN retry limit exceeded")
                              self._notify("tx_failed"); self._reset_state(); return
                          gr.log.warn(f"FSM: SYN RTO retry {self.ctrl_retries}/{self.max_retries}")
                          self._emit_ctrl(PKT_SYN, total_pkts=self.total_tx, media=self.media_code)
                          self._start_timer(ctrl)
                      elif self.state == FIN_SENT:
                          self.ctrl_retries += 1
                          if self.ctrl_retries > self.max_retries:
                              gr.log.warn("FSM: FIN retry limit exceeded")
                              self._notify("tx_done"); self._reset_state(); return
                          gr.log.warn(f"FSM: FIN RTO retry {self.ctrl_retries}/{self.max_retries}")
                          self._emit_ctrl(PKT_FIN)
                          self._start_timer(ctrl)
                      elif self.state in (SYN_RCVD, RX_ACTIVE):
                          gr.log.warn("FSM: peer went silent - abandoning RX session")
                          self._reset_state()
                  else:
                      if self.state == TX_ACTIVE and not self.acked[slot] and self.tx_buf[slot] is not None:
                          self.data_retries[slot] += 1
                          if self.data_retries[slot] > self.max_retries:
                              gr.log.error(f"FSM: DATA retry limit exceeded slot={slot}")
                              self._notify("tx_failed"); self._reset_state(); return
                          gr.log.warn(f"FSM: DATA RTO slot={slot}")
                          self._emit_data(slot); self._start_timer(slot)

          def handle_app_in(self, msg):
              if not pmt.is_pair(msg): return
              d = pmt.cdr(msg)
              if not pmt.is_u8vector(d): return
              frame = bytes(pmt.u8vector_elements(d))
              if len(frame) < 8:
                  gr.log.error("FSM app_in: frame too short"); return
              dst_addr, dst_port, type_byte, _ = struct.unpack_from(">BBBB", frame, 0)
              declared_len = struct.unpack_from(">I", frame, 4)[0]
              if len(frame) != 8 + declared_len:
                  gr.log.error("FSM app_in: length mismatch"); return
              with self._lock:
                  if self.state != IDLE:
                      gr.log.warn("FSM app_in: session active - dropping")
                      self._notify("tx_busy"); return
                  self.dst_addr = dst_addr & 0xFF; self.dst_port = dst_port & 0xFF
                  self.media_code = type_byte & 0xFF
                  self._packetize(frame)
                  self.session_id   = int.from_bytes(os.urandom(8), "big")
                  self.state        = SYN_SENT; self.ctrl_retries = 0
                  self._emit_ctrl(PKT_SYN, total_pkts=self.total_tx, media=self.media_code)
                  self._start_timer(self.seq_space)

          def handle_pdu_in(self, msg):
              if not pmt.is_pair(msg): return
              meta = pmt.car(msg); data = pmt.cdr(msg)
              if not pmt.is_dict(meta): return
              if not pmt.dict_has_key(meta, pmt.intern("pkt_type")): return
              pkt_str  = pmt.symbol_to_string(
                  pmt.dict_ref(meta, pmt.intern("pkt_type"), pmt.intern("")))
              pkt_code = PKT_CODE.get(pkt_str, 0)
              sid      = pmt.to_uint64(
                  pmt.dict_ref(meta, pmt.intern("session_id"), pmt.from_uint64(0)))
              payload  = bytes(pmt.u8vector_elements(data)) if pmt.is_u8vector(data) else b""
              def gu(k, d=0):
                  return pmt.to_uint64(pmt.dict_ref(meta, pmt.intern(k), pmt.from_uint64(d)))
              def gs(k, d=""):
                  return pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern(k), pmt.intern(d)))
              with self._lock:
                  if self.state != IDLE and pkt_code != PKT_SYN:
                      if sid != self.session_id: return
                  hdr = {"pkt_type":pkt_code, "media_type":MEDIA_CODE.get(gs("media_type"), 0),
                         "src_addr":gu("src_addr"), "src_port":gu("src_port"),
                         "dst_addr":gu("dst_addr"), "dst_port":gu("dst_port"),
                         "seq_no":gu("seq_no"), "total_pkts":gu("total_pkts"),
                         "session_id":sid}
                  dispatch = {IDLE:self._fsm_idle, SYN_SENT:self._fsm_syn_sent,
                              SYN_RCVD:self._fsm_syn_rcvd, TX_ACTIVE:self._fsm_tx_active,
                              RX_ACTIVE:self._fsm_rx_active, FIN_SENT:self._fsm_fin_sent}
                  if self.state in dispatch:
                      dispatch[self.state](hdr, payload)
                  if self.state in (SYN_RCVD, RX_ACTIVE):
                      self._start_timer(self.seq_space, self.rto_s * (self.max_retries + 2))

          def _fsm_idle(self, hdr, payload):
              if hdr["session_id"] == self.last_done_sid and hdr["pkt_type"] in (PKT_DATA, PKT_FIN):
                  self.session_id = hdr["session_id"]
                  self.dst_addr = hdr["src_addr"]; self.dst_port = hdr["src_port"]
                  if hdr["pkt_type"] == PKT_DATA: self._emit_ctrl(PKT_ACK, seq_no=hdr["seq_no"])
                  else:                           self._emit_ctrl(PKT_FIN_ACK)
                  self.session_id = 0; self.dst_addr = 0; self.dst_port = 0
                  return
              if hdr["pkt_type"] != PKT_SYN: return
              dst = hdr["dst_addr"]
              if self.local_addr != 0 and dst != 0 and dst != self.local_addr: return
              if self.local_port != 0 and hdr["dst_port"] != 0 and hdr["dst_port"] != self.local_port: return
              self.dst_addr=hdr["src_addr"]; self.dst_port=hdr["src_port"]
              self.session_id=hdr["session_id"]; self.total_rx=hdr["total_pkts"]
              self.media_code=hdr["media_type"]
              self.rcv_base=0; self.pkts_delivered=0; self.reassembled=bytearray()
              self.rx_buf=[None]*self.seq_space; self.received=[False]*self.seq_space
              self.state=SYN_RCVD; self._emit_ctrl(PKT_SYN_ACK)

          def _fsm_syn_sent(self, hdr, payload):
              if hdr["pkt_type"] != PKT_SYN_ACK: return
              self._cancel_timer(self.seq_space)
              self.state=TX_ACTIVE; self.send_base=0; self.next_seq_abs=0
              for _ in range(min(self.win_size, self.total_tx)):
                  slot=self.next_seq_abs % self.seq_space
                  self.tx_buf[slot]=self.all_tx_pkts[self.next_seq_abs]; self.acked[slot]=False; self.data_retries[slot]=0
                  self._emit_data(slot); self._start_timer(slot); self.next_seq_abs+=1

          def _fsm_syn_rcvd(self, hdr, payload):
              if hdr["pkt_type"]==PKT_SYN: self._emit_ctrl(PKT_SYN_ACK); return
              if hdr["pkt_type"]==PKT_DATA: self.state=RX_ACTIVE; self._fsm_rx_active(hdr, payload)

          def _fsm_tx_active(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_ACK: return
              seq=hdr["seq_no"]
              if self.acked[seq]: return
              self.acked[seq]=True; self._cancel_timer(seq); self._advance_window()

          def _fsm_rx_active(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_DATA: return
              seq=hdr["seq_no"]
              in_win=any(seq==(self.rcv_base+i)%self.seq_space for i in range(self.win_size))
              self._emit_ctrl(PKT_ACK, seq_no=seq)
              if not in_win: return
              if not self.received[seq]: self.received[seq]=True; self.rx_buf[seq]=payload
              self._try_deliver()

          def _fsm_fin_sent(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_FIN_ACK: return
              self._cancel_timer(self.seq_space); self._notify("tx_done"); self._reset_state()

          def _advance_window(self):
              while self.send_base < self.total_tx and self.acked[self.send_base % self.seq_space]:
                  slot=self.send_base%self.seq_space
                  self.acked[slot]=False; self.tx_buf[slot]=None; self.send_base+=1
                  if self.next_seq_abs < self.total_tx:
                      ns=self.next_seq_abs%self.seq_space
                      self.tx_buf[ns]=self.all_tx_pkts[self.next_seq_abs]; self.acked[ns]=False; self.data_retries[ns]=0
                      self._emit_data(ns); self._start_timer(ns); self.next_seq_abs+=1
              if self.send_base >= self.total_tx:
                  self.state=FIN_SENT; self.ctrl_retries=0
                  self._emit_ctrl(PKT_FIN); self._start_timer(self.seq_space)

          def _try_deliver(self):
              while self.pkts_delivered < self.total_rx and self.received[self.rcv_base]:
                  self.reassembled.extend(self.rx_buf[self.rcv_base])
                  self.received[self.rcv_base]=False; self.rx_buf[self.rcv_base]=None
                  self.rcv_base=(self.rcv_base+1)%self.seq_space; self.pkts_delivered+=1
              if self.pkts_delivered == self.total_rx:
                  out=bytes(self.reassembled)
                  m=pmt.make_dict()
                  for k,v in [("payload_type",pmt.intern(MEDIA_STR.get(self.media_code,"unknown"))),
                              ("session_id",pmt.from_uint64(self.session_id)),
                              ("src_addr",pmt.from_uint64(self.dst_addr)),
                              ("src_port",pmt.from_uint64(self.dst_port)),
                              ("dst_addr",pmt.from_uint64(self.local_addr)),
                              ("dst_port",pmt.from_uint64(self.local_port))]:
                      m=pmt.dict_add(m, pmt.intern(k), v)
                  self.message_port_pub(pmt.intern("app_out"),
                      pmt.cons(m, pmt.init_u8vector(len(out), list(out))))
                  self._emit_ctrl(PKT_FIN_ACK)
                  self.last_done_sid = self.session_id
                  self._reset_state()

          def _notify(self, event):
              m = pmt.dict_add(pmt.make_dict(), pmt.intern("event"), pmt.intern(event))
              m = pmt.dict_add(m, pmt.intern("session_id"), pmt.from_uint64(self.session_id))
              # 1-byte dummy payload: an EMPTY u8vector crashes the C++ ZMQ sink's serializer
              # on distros built with _GLIBCXX_ASSERTIONS (Fedora): "Assertion '__n < this->size()'"
              self.message_port_pub(pmt.intern("app_out"), pmt.cons(m, pmt.init_u8vector(1, [0])))

          def _packetize(self, raw):
              self.all_tx_pkts=[raw[i:i+self.mtu] for i in range(0,len(raw),self.mtu)]
              self.tx_buf=[None]*self.seq_space; self.acked=[False]*self.seq_space
              self.total_tx=len(self.all_tx_pkts); self.send_base=0; self.next_seq_abs=0

          def _make_meta(self, pkt_code, seq_no=0, total_pkts=0, media=0):
              m=pmt.make_dict()
              for k,v in [("pkt_type",pmt.intern(PKT_STR.get(pkt_code,"UNKNOWN"))),
                          ("pkt_type_raw",pmt.from_uint64(pkt_code)),
                          ("seq_no",pmt.from_uint64(seq_no)),
                          ("total_pkts",pmt.from_uint64(total_pkts)),
                          ("media_type",pmt.intern(MEDIA_STR.get(media,"unknown"))),
                          ("media_raw",pmt.from_uint64(media)),
                          ("src_addr",pmt.from_uint64(self.local_addr)),
                          ("src_port",pmt.from_uint64(self.local_port)),
                          ("dst_addr",pmt.from_uint64(self.dst_addr)),
                          ("dst_port",pmt.from_uint64(self.dst_port)),
                          ("session_id",pmt.from_uint64(self.session_id))]:
                  m=pmt.dict_add(m, pmt.intern(k), v)
              return m

          def _emit_ctrl(self, pkt_code, seq_no=0, total_pkts=0, media=None):
              if media is None: media=self.media_code
              meta=self._make_meta(pkt_code, seq_no=seq_no, total_pkts=total_pkts, media=media)
              self.message_port_pub(pmt.intern("pdu_out"),
                  pmt.cons(meta, pmt.init_u8vector(0, [])))

          def _emit_data(self, slot):
              chunk=self.tx_buf[slot]
              if chunk is None: return
              meta=self._make_meta(PKT_DATA, seq_no=slot, total_pkts=self.total_tx, media=self.media_code)
              self.message_port_pub(pmt.intern("pdu_out"),
                  pmt.cons(meta, pmt.init_u8vector(len(chunk), list(chunk))))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 2: SR-ARQ FSM Core'
    local_addr: tl_local_addr
    local_port: tl_local_port
    m: tl_m
    max_retries: tl_max_retries
    mtu_bytes: tl_mtu
    node_role: tl_role
    rto_ms: tl_rto_ms
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import struct, pmt
      from gnuradio import gr

      HDR_FMT    = ">BBBBBBHHQ"
      PKT_CODE   = {"SYN":0x01, "SYN_ACK":0x02, "DATA":0x03,
                    "ACK":0x04, "FIN":0x05, "FIN_ACK":0x06}
      MEDIA_CODE = {"text":0x01, "image":0x02, "audio":0x03}


      class blk(gr.sync_block):
          """Block 3: TX Header Serializer -- stateless 18-byte binary header serializer."""

          def __init__(self):
              gr.sync_block.__init__(self, name='TX Header Serializer',
                                     in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg): return
              meta = pmt.car(msg); data = pmt.cdr(msg)
              if not pmt.is_dict(meta): return
              def gu(k, d=0):
                  return pmt.to_uint64(pmt.dict_ref(meta, pmt.intern(k), pmt.from_uint64(d)))
              def gs(k, d=""):
                  return pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern(k), pmt.intern(d)))
              hdr = struct.pack(HDR_FMT,
                  PKT_CODE.get(gs("pkt_type"), 0),
                  MEDIA_CODE.get(gs("media_type"), 0),
                  gu("src_addr") & 0xFF, gu("src_port") & 0xFF,
                  gu("dst_addr") & 0xFF, gu("dst_port") & 0xFF,
                  gu("seq_no")    & 0xFFFF,
                  gu("total_pkts") & 0xFFFF,
                  gu("session_id"))
              payload  = bytes(pmt.u8vector_elements(data)) if pmt.is_u8vector(data) else b""
              frame    = hdr + payload
              out_data = pmt.init_u8vector(len(frame), list(frame))
              self.message_port_pub(pmt.intern("pdus"), pmt.cons(meta, out_data))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 3: TX Header Serializer'
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: int(1.5e6)
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(1.5e6)
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: int(rx_freq)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: |-
      import os
      from gnuradio import zeromq
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    comment: Unicast filter
    invert: 'False'
    k: pmt.intern("dst_addr")
    v: pmt.from_uint64(tl_local_addr)
  states: {}
- name: pdu_pdu_filter_0_0
  id: pdu_pdu_filter
  parameters:
    comment: Broadcast filter
    invert: 'False'
    k: pmt.intern("dst_addr")
    v: pmt.from_uint64(0)
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}
- name: zeromq_pub_sink_iq
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:" + str(iq_tx_port)'
    comment: 'SIM: replaces the Pluto sink'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://127.0.0.1:" + str(tl_zmq_tx_port)'
    bind: 'True'
    comment: Binds and receives from folder_sync_daemon PUSH (port tl_zmq_tx_port)
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://127.0.0.1:" + str(tl_zmq_rx_port)'
    comment: Binds and sends reassembled data to folder_sync_daemon PULL (port tl_zmq_rx_port)
    timeout: '100'
  states: {}
- name: zeromq_sub_source_iq
  id: zeromq_sub_source
  parameters:
    address: '"tcp://127.0.0.1:" + str(iq_rx_port)'
    comment: 'SIM: replaces the Pluto source'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', channels_channel_model_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_1, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_5_0, '0']
- [blocks_tag_gate_0_0, '0', zeromq_pub_sink_iq, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [channels_channel_model_0, '0', digital_fll_band_edge_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, pdus, pdu_pdu_filter_0, pdus]
- [epy_block_0, pdus, pdu_pdu_filter_0_0, pdus]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0_0, pdu_out, blocks_message_debug_0, print_pdu]
- [epy_block_0_0_0, pdu_out, epy_block_0, pdus]
- [epy_block_1, app_out, zeromq_push_msg_sink_0, in]
- [epy_block_1, pdu_out, epy_block_2, pdus]
- [epy_block_2, pdus, blocks_message_debug_1, print_pdu]
- [epy_block_2, pdus, epy_block_0_0, msg_in]
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [pdu_pdu_filter_0, pdus, epy_block_1, pdu_in]
- [pdu_pdu_filter_0_0, pdus, epy_block_1, pdu_in]
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', blocks_copy_0_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print_pdu]
- [zeromq_pull_msg_source_0, out, epy_block_1, app_in]
- [zeromq_sub_source_iq, '0', blocks_copy_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
