options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: transeciever_sim
    output_language: python
    title: 'CDP transceiver - Stage 3 (adaptive + encryption) (SIM: ZMQ IQ, no radio)'
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    comment: SDR URI (env TL_SDR_URI)
    value: os.environ.get('TL_SDR_URI', 'ip:192.168.1.10')
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: MCS_MODE
  id: variable_qtgui_chooser
  parameters:
    comment: 'STAGE 2: Auto = follow the peer''s request'
    label: Modulation
    label0: Auto
    label1: BPSK
    label2: QPSK
    num_opts: '3'
    option0: '-1'
    option1: '0'
    option2: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: int(os.environ.get('TL_MCS_MODE', '-1'))
    widget: radio_buttons
  states: {}
- name: MY_ID
  id: variable
  parameters:
    value: tl_local_addr
  states: {}
- name: PRIME
  id: variable
  parameters:
    value: '257'
  states: {}
- name: PRIVATE_KEY
  id: variable
  parameters:
    comment: this node's private key (inverse of its public key mod 256)
    value: int(os.environ.get('TL_PRIVKEY', '241'))
  states: {}
- name: PUBLIC_KEY_MINE
  id: variable
  parameters:
    comment: for reference only (give it to the peer)
    value: int(os.environ.get('TL_PUBKEY', '17'))
  states: {}
- name: PUBLIC_KEY_PEER
  id: variable
  parameters:
    comment: 'the PEER''s public key: used to encrypt what we send'
    value: int(os.environ.get('TL_PEER_PUBKEY', '17'))
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: TX_FREQ_A
  id: variable
  parameters:
    value: 2412e6
  states: {}
- name: TX_FREQ_B
  id: variable
  parameters:
    value: 2437e6
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    modulus: '4'
    step_size: '.01'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: fdd_side
  id: variable
  parameters:
    comment: |-
      FDD: side A transmits on TX_FREQ_A and
      listens on TX_FREQ_B; side B the reverse.
      Default: lower address = A.
    value: os.environ.get('TL_FDD_SIDE', 'A' if tl_local_addr < tl_peer_addr else 'B')
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: iq_rx_port
  id: variable
  parameters:
    value: 53002 if fdd_side == 'A' else 53001
  states: {}
- name: iq_tx_port
  id: variable
  parameters:
    comment: 'SIM only: ZMQ IQ ports replacing the radio'
    value: 53001 if fdd_side == 'A' else 53002
  states: {}
- name: nv
  id: variable_qtgui_range
  parameters:
    comment: |-
      Extra noise added after the AGC
      (0 = off). Use it to test the link.
    label: RX extra noise (nv)
    start: '0'
    step: '0.01'
    stop: '1'
    value: float(os.environ.get('TL_NOISE', '0'))
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: TX_FREQ_B if fdd_side == 'A' else TX_FREQ_A
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.020'
  states: {}
- name: tl_local_addr
  id: variable
  parameters:
    value: int(os.environ.get('TL_LOCAL_ADDR', '1'))
  states: {}
- name: tl_local_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_LOCAL_PORT', '1'))
  states: {}
- name: tl_m
  id: variable
  parameters:
    value: int(os.environ.get('TL_M', '4'))
  states: {}
- name: tl_max_retries
  id: variable
  parameters:
    value: int(os.environ.get('TL_MAX_RETRIES', '10'))
  states: {}
- name: tl_mtu
  id: variable
  parameters:
    value: int(os.environ.get('TL_MTU', '200'))
  states: {}
- name: tl_peer_addr
  id: variable
  parameters:
    value: int(os.environ.get('TL_PEER_ADDR', '2'))
  states: {}
- name: tl_role
  id: variable
  parameters:
    value: os.environ.get('TL_ROLE', 'initiator')
  states: {}
- name: tl_rto_ms
  id: variable
  parameters:
    value: int(os.environ.get('TL_RTO_MS', '500'))
  states: {}
- name: tl_zmq_rx_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_ZMQ_RX_PORT', '52002'))
  states: {}
- name: tl_zmq_tx_port
  id: variable
  parameters:
    value: int(os.environ.get('TL_ZMQ_TX_PORT', '52001'))
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: TX_FREQ_A if fdd_side == 'A' else TX_FREQ_B
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: Test noise (nv slider). Pass-through at nv = 0.
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: nv
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {state: disabled}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    comment: 'STAGE 2: order 4 (QPSK grid for both modes)'
    order: '4'
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11* sps +1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '15'
    sps: '2'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '0.05'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import struct, pmt
      from gnuradio import gr

      HDR_FMT  = ">BBBBBBHHQ"
      HDR_SIZE = struct.calcsize(HDR_FMT)  # 18

      PKT_STR   = {0x01:"SYN", 0x02:"SYN_ACK", 0x03:"DATA",
                   0x04:"ACK", 0x05:"FIN", 0x06:"FIN_ACK"}
      MEDIA_STR = {0x01:"text", 0x02:"image", 0x03:"audio"}


      class blk(gr.sync_block):
          """Block 1: RX Header Parser -- stateless 18-byte binary header deserializer."""

          def __init__(self):
              gr.sync_block.__init__(self, name='RX Header Parser',
                                     in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg): return
              in_meta = pmt.car(msg)
              in_data = pmt.cdr(msg)
              if not pmt.is_u8vector(in_data): return
              raw = bytes(pmt.u8vector_elements(in_data))
              if len(raw) < HDR_SIZE: return
              fields   = struct.unpack_from(HDR_FMT, raw)
              pkt_type = fields[0]
              if not (0x01 <= pkt_type <= 0x06): return
              meta = in_meta if pmt.is_dict(in_meta) else pmt.make_dict()
              for k, v in [
                  ("pkt_type",     pmt.intern(PKT_STR.get(pkt_type, "UNKNOWN"))),
                  ("pkt_type_raw", pmt.from_uint64(pkt_type)),
                  ("media_type",   pmt.intern(MEDIA_STR.get(fields[1], "unknown"))),
                  ("src_addr",     pmt.from_uint64(fields[2])),
                  ("src_port",     pmt.from_uint64(fields[3])),
                  ("dst_addr",     pmt.from_uint64(fields[4])),
                  ("dst_port",     pmt.from_uint64(fields[5])),
                  ("seq_no",       pmt.from_uint64(fields[6])),
                  ("total_pkts",   pmt.from_uint64(fields[7])),
                  ("session_id",   pmt.from_uint64(fields[8])),
              ]:
                  meta = pmt.dict_add(meta, pmt.intern(k), v)
              payload  = raw[HDR_SIZE:]
              out_data = pmt.init_u8vector(len(payload), list(payload))
              self.message_port_pub(pmt.intern("pdus"), pmt.cons(meta, out_data))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 1: RX Header Parser'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Adaptive Burst Packet Framer TX (BPSK / QPSK)

      Builds every burst as complex SYMBOLS (1 sample/symbol). Feed pdu_out into
      PDU to Tagged Stream (Complex) -> Root Raised Cosine Filter (interpolating, interp = sps,
      gain = sps) -> Tag Gate -> PlutoSDR Sink.

      Modulation
      - One QPSK grid (diagonal points, |s| = 1) for both modes, so one 4th-order Costas loop
        on the RX side handles everything.
      - Differential encoding is done here, per burst, from a known reference symbol:
          BPSK : 1 bit/symbol,  bit b -> phase step of b * 180 deg
          QPSK : 2 bits/symbol, dibit -> Gray-coded phase step of 0/90/180/270 deg
      - Preamble, sync word and header are ALWAYS BPSK; only payload + CRC switch.
      - Postamble: postamble_len*8 symbols of constant phase (= the 160 zero bytes of the BPSK
        framer: a plain carrier). They push the last real samples out of the RRC filter and the
        Pluto sink's 4096-sample buffer, and keep the RX AGC level steady until the burst ends.

      Frame (bytes before modulation)
        [preamble] [1A CF FC 1D] [hdr 8B] [payload] [CRC32 4B] [postamble carrier]
        hdr = len(2) | dest_id(1) | msg_id(1) | rep(1) | n_reps(1) | flags(1) | hdr_crc8(1)
        flags bit0 = payload MCS (0 BPSK, 1 QPSK); bit1 = "request valid";
              bit2 = MCS this node wants the PEER to use towards it
        dest_id = the PDU's 'dst_addr' metadata (from the SR-ARQ FSM), else the peer_id parameter.

      Link adaptation (mcs_mode: -1 auto, 0 force BPSK, 1 force QPSK)
      - link_in gets a dict from this node's deframer: my_req/snr_db (what we ask the peer for,
        carried in our headers) and peer_req (what the peer asked us to use).
      - Auto mode uses peer_req while it is fresh (feedback_timeout s), else BPSK.
      - Payloads shorter than qpsk_min_len (SYN/ACK/FIN control PDUs) are always BPSK.
      - If QPSK frames get no reply at all from the peer for fallback_s seconds, the framer drops
        to BPSK until the peer is heard again (the peer cannot send feedback for frames it lost).
      """
      import time
      import zlib

      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      GRAY = np.array([0, 1, 3, 2], dtype=np.int64)   # dibit value -> phase step (x 90 deg)


      def crc8(data, poly=0x07):
          crc = 0
          for byte in data:
              crc ^= byte
              for _ in range(8):
                  crc = ((crc << 1) ^ poly) & 0xFF if crc & 0x80 else (crc << 1) & 0xFF
          return crc


      def build_header(length, dest_id, msg_id, rep, n_reps, mcs, req_valid, req_mcs):
          flags = (mcs & 1) | ((1 if req_valid else 0) << 1) | ((req_mcs & 1) << 2)
          h7 = length.to_bytes(2, "big") + bytes([dest_id & 0xFF, msg_id & 0xFF, rep & 0xFF, n_reps & 0xFF, flags])
          return h7 + bytes([crc8(h7)])


      def frame_to_symbols(bpsk_part, qpsk_part=b"", n_tail=0):
          """bpsk_part sent 1 bit/symbol, qpsk_part 2 bits/symbol, then n_tail constant-phase
          symbols; one leading reference symbol."""
          bb = np.unpackbits(np.frombuffer(bpsk_part, np.uint8)).astype(np.int64)
          steps = [2 * bb]
          if qpsk_part:
              qb = np.unpackbits(np.frombuffer(qpsk_part, np.uint8)).astype(np.int64)
              steps.append(GRAY[2 * qb[0::2] + qb[1::2]])
          steps.append(np.zeros(n_tail, np.int64))
          phase = np.concatenate(([0], np.cumsum(np.concatenate(steps)))) & 3
          return np.exp(1j * (np.pi / 4 + phase * np.pi / 2)).astype(np.complex64)


      class PacketFramerTX(gr.basic_block):
          def __init__(self, peer_id=1, preamble_len=1024, repeat_count=1, max_payload_len=8192,
                       preamble_byte=0xFF, postamble_len=160, mcs_mode=-1, feedback_timeout=30.0,
                       qpsk_min_len=32, fallback_s=1.0):
              gr.basic_block.__init__(self, name="Adaptive Packet Framer TX", in_sig=None, out_sig=None)
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self.postamble_len = max(0, int(postamble_len))
              self.mcs_mode = int(mcs_mode)
              self.feedback_timeout = float(feedback_timeout)
              self.qpsk_min_len = int(qpsk_min_len)
              self.fallback_s = float(fallback_s)
              self._msg_id = 0

              self._peer_req = None          # MCS the peer asked us to use
              self._peer_req_t = 0.0
              self._my_req = None            # MCS our receiver wants the peer to use
              self._my_snr = None
              self._qpsk_unanswered = None   # time of the first QPSK frame sent since we last heard the peer

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_in(pmt.intern("link_in"))
              self.set_msg_handler(pmt.intern("link_in"), self.handle_link)
              self.message_port_register_out(pmt.intern("pdu_out"))

          # ------------------------------------------------------------------ feedback
          def handle_link(self, msg):
              if not pmt.is_dict(msg):
                  return
              self._qpsk_unanswered = None   # we heard the peer
              k_peer, k_my, k_snr = pmt.intern("peer_req"), pmt.intern("my_req"), pmt.intern("snr_db")
              if pmt.dict_has_key(msg, k_peer):
                  self._peer_req = 1 if pmt.to_long(pmt.dict_ref(msg, k_peer, pmt.PMT_NIL)) == 1 else 0
                  self._peer_req_t = time.monotonic()
              if pmt.dict_has_key(msg, k_my):
                  self._my_req = 1 if pmt.to_long(pmt.dict_ref(msg, k_my, pmt.PMT_NIL)) == 1 else 0
              if pmt.dict_has_key(msg, k_snr):
                  self._my_snr = pmt.to_double(pmt.dict_ref(msg, k_snr, pmt.PMT_NIL))

          def _select_mcs(self, n_payload):
              mode = int(self.mcs_mode)
              if mode in (0, 1):
                  return mode, "forced"
              if n_payload < self.qpsk_min_len:
                  return 0, "short frame"
              now = time.monotonic()
              if self._peer_req is None:
                  return 0, "no feedback yet"
              if now - self._peer_req_t >= self.feedback_timeout:
                  return 0, "feedback stale"
              if self._peer_req == 0:
                  return 0, "peer request"
              if self._qpsk_unanswered is None:
                  self._qpsk_unanswered = now
              elif now - self._qpsk_unanswered > self.fallback_s:
                  return 0, "QPSK unanswered, fallback"
              return 1, "peer request"

          # ------------------------------------------------------------------ data
          def _dest_of(self, msg):
              if pmt.is_pair(msg) and pmt.is_dict(pmt.car(msg)):
                  key = pmt.intern("dst_addr")
                  if pmt.dict_has_key(pmt.car(msg), key):
                      v = pmt.dict_ref(pmt.car(msg), key, pmt.PMT_NIL)
                      try:
                          return int(pmt.to_uint64(v)) & 0xFF
                      except Exception:
                          try:
                              return int(pmt.to_long(v)) & 0xFF
                          except Exception:
                              pass
              return self.peer_id

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def handle_msg(self, msg):
              dest = self._dest_of(msg)
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return
              if not payload:
                  return
              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[:self.max_payload_len]

              mcs, why = self._select_mcs(len(payload))
              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))
              preamble = bytes([self.preamble_byte]) * self.preamble_len
              req_valid = self._my_req is not None
              req = self._my_req if req_valid else 0

              ask = ("QPSK" if req else "BPSK") if req_valid else "-"
              snr = f" rxSNR {self._my_snr:.1f}dB" if self._my_snr is not None else ""
              print(f"[TX] #{msg_id} -> {dest} {'QPSK' if mcs else 'BPSK'} ({why}) {len(payload)} B"
                    f"{f' x{n_reps}' if n_reps > 1 else ''} | ask peer: {ask}{snr}", flush=True)

              n_tail = self.postamble_len * 8
              for rep in range(n_reps):
                  hdr = build_header(len(payload), dest, msg_id, rep, n_reps, mcs, req_valid, req)
                  crc = zlib.crc32(hdr + payload).to_bytes(4, "big")
                  head = preamble + SYNC_WORD + hdr
                  body = payload + crc
                  if mcs == 0:
                      syms = frame_to_symbols(head + body, n_tail=n_tail)
                  else:
                      syms = frame_to_symbols(head, body, n_tail=n_tail)
                  vec = pmt.init_c32vector(len(syms), syms.tolist())
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(pmt.PMT_NIL, vec))
    comment: 'STAGE 2: adaptive framer (complex symbols)'
    fallback_s: '1.0'
    feedback_timeout: '30.0'
    max_payload_len: '8192'
    mcs_mode: MCS_MODE
    peer_id: tl_peer_addr
    postamble_len: '160'
    preamble_byte: '0xFF'
    preamble_len: '1024'
    qpsk_min_len: '32'
    repeat_count: '1'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: Adaptive Burst Packet Deframer RX (BPSK / QPSK)

      Input: complex symbols (1 sample/symbol) straight from the Costas loop (order 4).
      No constellation decoder / diff decoder / unpack blocks are needed.

      - Differential detection z[n] = r[n] * conj(r[n-1]): independent of carrier phase, so
        the Costas 90/180 deg ambiguity does not matter and every burst starts clean.
          BPSK bits : Re(z) < 0          QPSK bits : angle(z) quantised to 90 deg, Gray-decoded
      - Sync + header are always BPSK. Header CRC-8 is checked before len/MCS are trusted.
      - Payload decoded with the header's MCS; CRC32 over hdr + payload.
      - Accepts frames for this node (dest_id == peer_id, i.e. MY_ID) or broadcast (dest_id 0).
      - Data-aided SNR on every CRC-valid frame for us: the sent symbols are rebuilt from the
        decoded bits, the local complex gain is tracked with a sliding average, and
        SNR = |gain|^2 / residual power. Idle noise is never measured.
      - Hysteresis (snr_up_db / snr_down_db) on the averaged SNR decides which MCS we ask the peer
        for (my_req). A header-valid QPSK frame for us that fails CRC asks for BPSK at once.
      - link_out (dict) -> framer link_in: my_req, snr_db, and peer_req (the peer's request to us).
      - pdu_out meta: dest_id, msg_id, n_reps, mcs, snr_db (the RX header parser keeps them).
      """
      import zlib

      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      HDR_BYTES = 8
      SYNC_BITS = 32
      HDR_BITS = HDR_BYTES * 8
      GRAY_INV = np.array([0, 1, 3, 2], dtype=np.int64)   # phase step -> dibit value


      def crc8(data, poly=0x07):
          crc = 0
          for byte in data:
              crc ^= byte
              for _ in range(8):
                  crc = ((crc << 1) ^ poly) & 0xFF if crc & 0x80 else (crc << 1) & 0xFF
          return crc


      class PacketDeframerRX(gr.sync_block):
          def __init__(self, peer_id=1, max_bit_errors=1, max_payload_len=8192, sym_rate=375000,
                       snr_up_db=16.0, snr_down_db=13.0, snr_avg=0.2, verbose=1):
              gr.sync_block.__init__(self, name="Adaptive Packet Deframer RX",
                                     in_sig=[np.complex64], out_sig=None)
              self.peer_id = int(peer_id) & 0xFF          # this node's own link address (MY_ID)
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.sym_rate = float(sym_rate)
              self.snr_up_db = float(snr_up_db)
              self.snr_down_db = float(snr_down_db)
              self.snr_avg = float(snr_avg)
              self.verbose = int(verbose)

              self._sync = (np.unpackbits(np.frombuffer(SYNC_WORD, np.uint8)).astype(np.int16) * 2 - 1)
              self._sym = np.zeros(0, dtype=np.complex64)

              self.n_sync = self.n_ok = self.n_crc_fail = self.n_bad_hdr = 0
              self._syms_total = 0
              self._syms_at_last_ok = 0
              self._cur_id = None
              self._cur_reps = set()
              self._cur_nreps = 0
              self._cur_mcs = 0
              self._cur_snr = []

              self._snr_ema = None
              self._my_req = 0

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("text_out"))
              self.message_port_register_out(pmt.intern("link_out"))

          # ------------------------------------------------------------------ helpers
          def _for_me(self, dest_id):
              return dest_id == self.peer_id or dest_id == 0

          def _publish_link(self, **kv):
              d = pmt.make_dict()
              for k, v in kv.items():
                  val = pmt.from_double(float(v)) if isinstance(v, float) else pmt.from_long(int(v))
                  d = pmt.dict_add(d, pmt.intern(k), val)
              self.message_port_pub(pmt.intern("link_out"), d)

          def _flush_summary(self):
              if self._cur_id is not None and self._cur_nreps > 1:
                  got, n = len(self._cur_reps), self._cur_nreps
                  loss = 100.0 * (n - got) / max(n, 1)
                  snr = f", SNR {np.mean(self._cur_snr):.1f} dB" if self._cur_snr else ""
                  print(f"[RX] msg #{self._cur_id}: {got}/{n} bursts OK (Loss: {loss:.0f}%) "
                        f"[{'QPSK' if self._cur_mcs else 'BPSK'}{snr}]", flush=True)
              self._cur_id = None
              self._cur_reps = set()
              self._cur_snr = []

          def _update_mcs(self, snr_db):
              a = self.snr_avg
              self._snr_ema = snr_db if self._snr_ema is None else (1 - a) * self._snr_ema + a * snr_db
              old = self._my_req
              if self._my_req == 0 and self._snr_ema > self.snr_up_db:
                  self._my_req = 1
              elif self._my_req == 1 and self._snr_ema < self.snr_down_db:
                  self._my_req = 0
              if self._my_req != old:
                  print(f"[LINK] avg SNR {self._snr_ema:.1f} dB -> asking peer for "
                        f"{'QPSK' if self._my_req else 'BPSK'}", flush=True)

          def _qpsk_failure(self):
              if self._my_req == 1:
                  print("[LINK] QPSK frame failed CRC -> asking peer for BPSK", flush=True)
              self._my_req = 0
              if self._snr_ema is not None:
                  self._snr_ema = min(self._snr_ema, self.snr_down_db)
              self._publish_link(my_req=self._my_req)

          @staticmethod
          def _snr_estimate(r, steps, win=33):
              """Data-aided SNR. r: received symbols (N+1), steps: phase steps (N, units of 90 deg)."""
              u = np.exp(1j * (np.pi / 2) * np.concatenate(([0], np.cumsum(steps))))
              w = r * np.conj(u)                          # = local gain + noise
              win = min(win, len(w) | 1)
              g = np.convolve(w, np.ones(win) / win, mode="valid")
              h = win // 2
              e = w[h:len(w) - h] - g
              noise = np.mean(np.abs(e) ** 2) * win / (win - 1)
              sig = np.mean(np.abs(g) ** 2) - noise / win
              return 10 * np.log10(max(sig / max(noise, 1e-12), 1e-3))

          def _deliver(self, hdr, payload, snr_db):
              dest_id, msg_id, rep, n_reps, flags = hdr[2], hdr[3], hdr[4], hdr[5], hdr[6]
              mcs = flags & 1
              # Feedback first, so the reply this frame triggers (SYN_ACK, ACK...) already carries it
              self._update_mcs(snr_db)
              link = dict(my_req=self._my_req, snr_db=float(self._snr_ema))
              if flags & 0x02:                       # the peer told us what it wants
                  link["peer_req"] = (flags >> 2) & 1
              self._publish_link(**link)

              if msg_id != self._cur_id:
                  self._flush_summary()
                  self._cur_id, self._cur_nreps, self._cur_mcs = msg_id, n_reps, mcs
                  if self.verbose >= 1:
                      print(f"[RX] #{msg_id} {'QPSK' if mcs else 'BPSK'} {len(payload)} B "
                            f"SNR {snr_db:.1f} dB", flush=True)
                  if self.verbose >= 2:
                      print(f"     payload: {payload[:80]!r}", flush=True)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dest_id))
                  meta = pmt.dict_add(meta, pmt.intern("msg_id"), pmt.from_long(msg_id))
                  meta = pmt.dict_add(meta, pmt.intern("n_reps"), pmt.from_long(n_reps))
                  meta = pmt.dict_add(meta, pmt.intern("mcs"), pmt.from_long(mcs))
                  meta = pmt.dict_add(meta, pmt.intern("snr_db"), pmt.from_double(float(snr_db)))
                  vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
                  self.message_port_pub(pmt.intern("text_out"),
                                        pmt.intern(payload.decode("utf-8", errors="replace")))

              self._cur_reps.add(rep)
              self._cur_snr.append(snr_db)
              self._syms_at_last_ok = self._syms_total

          # ------------------------------------------------------------------ work
          def work(self, input_items, output_items):
              x = input_items[0]
              n_in = len(x)
              self._syms_total += n_in
              self._sym = np.concatenate((self._sym, x)) if len(self._sym) else x.copy()

              if self._cur_id is not None and self._syms_total - self._syms_at_last_ok > 0.5 * self.sym_rate:
                  self._flush_summary()

              sym = self._sym
              if len(sym) < SYNC_BITS + HDR_BITS + 1:
                  return n_in

              z = sym[1:] * np.conj(sym[:-1])               # z[k] uses sym[k] and sym[k+1]
              nz = len(z)
              bits = (z.real < 0).astype(np.uint8)          # BPSK-mode hard bits
              pm = bits.astype(np.int16) * 2 - 1
              corr = np.lib.stride_tricks.sliding_window_view(pm, SYNC_BITS) @ self._sync
              cand = np.flatnonzero(corr >= SYNC_BITS - 2 * self.max_bit_errors)

              pos = 0           # z index up to which everything is consumed
              waiting = None    # z index of a frame that is still incomplete
              for i in cand:
                  i = int(i)
                  if i < pos:
                      continue                              # inside a frame already decoded
                  h0 = i + SYNC_BITS
                  if h0 + HDR_BITS > nz:
                      waiting = i                           # header not complete yet
                      break
                  hdr = np.packbits(bits[h0:h0 + HDR_BITS]).tobytes()
                  length = int.from_bytes(hdr[:2], "big")
                  if crc8(hdr[:7]) != hdr[7] or length == 0 or length > self.max_payload_len:
                      self.n_bad_hdr += 1                   # false sync: try the next candidate
                      continue

                  mcs = hdr[6] & 1
                  p0 = h0 + HDR_BITS
                  nbytes = length + 4
                  end = p0 + (nbytes * 8 if mcs == 0 else nbytes * 4)
                  if end > nz:
                      waiting = i                           # wait for the rest of the frame
                      break

                  if mcs == 0:
                      pay_steps = 2 * bits[p0:end].astype(np.int64)
                      body = np.packbits(bits[p0:end]).tobytes()
                  else:
                      pay_steps = np.rint(np.angle(z[p0:end]) / (np.pi / 2)).astype(np.int64) & 3
                      v = GRAY_INV[pay_steps]
                      qbits = np.empty(2 * len(v), dtype=np.uint8)
                      qbits[0::2] = v >> 1
                      qbits[1::2] = v & 1
                      body = np.packbits(qbits).tobytes()

                  payload, rx_crc = body[:length], body[length:length + 4]
                  self.n_sync += 1
                  if zlib.crc32(hdr + payload) == int.from_bytes(rx_crc, "big"):
                      if self._for_me(hdr[2]):
                          self.n_ok += 1
                          steps = np.concatenate((2 * bits[i:p0].astype(np.int64), pay_steps))
                          snr_db = self._snr_estimate(sym[i:end + 1].astype(np.complex128), steps)
                          self._deliver(hdr, payload, snr_db)
                      pos = end                             # skip past the valid frame
                  else:
                      self.n_crc_fail += 1                  # next candidate (1-bit backtrack)
                      if mcs == 1 and self._for_me(hdr[2]):
                          self._qpsk_failure()

              keep = waiting if waiting is not None else max(pos, nz - (SYNC_BITS - 1))
              self._sym = sym[keep:].copy()
              return n_in
    comment: 'STAGE 2: adaptive deframer (complex in)'
    max_bit_errors: '1'
    max_payload_len: '8192'
    peer_id: MY_ID
    snr_avg: '0.2'
    snr_down_db: '13.0'
    snr_up_db: '16.0'
    sym_rate: samp_rate/sps
    verbose: '1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      # SR-ARQ FSM Core - patched: fixes A-E from INTEGRATION_NOTES.md (control timer slot,
      # post-session re-ACK, RX inactivity timeout, DATA retry cap, tx_done/tx_failed/tx_busy events)
      import os, struct, threading
      import pmt
      from gnuradio import gr

      PKT_SYN=0x01; PKT_SYN_ACK=0x02; PKT_DATA=0x03
      PKT_ACK=0x04; PKT_FIN=0x05; PKT_FIN_ACK=0x06
      MEDIA_CODE = {"text":0x01, "image":0x02, "audio":0x03}
      MEDIA_STR  = {0x01:"text", 0x02:"image", 0x03:"audio"}
      PKT_CODE   = {"SYN":PKT_SYN, "SYN_ACK":PKT_SYN_ACK, "DATA":PKT_DATA,
                    "ACK":PKT_ACK, "FIN":PKT_FIN, "FIN_ACK":PKT_FIN_ACK}
      PKT_STR    = {v:k for k,v in PKT_CODE.items()}
      IDLE="IDLE"; SYN_SENT="SYN_SENT"; SYN_RCVD="SYN_RCVD"
      TX_ACTIVE="TX_ACTIVE"; RX_ACTIVE="RX_ACTIVE"; FIN_SENT="FIN_SENT"


      class blk(gr.sync_block):
          """
          Block 2: SR-ARQ FSM Core
          Env vars: TL_M, TL_RTO_MS, TL_ROLE, TL_MTU, TL_LOCAL_ADDR,
                    TL_LOCAL_PORT, TL_MAX_RETRIES
          """

          def __init__(self,
                       m=int(os.environ.get('TL_M', '4')),
                       rto_ms=int(os.environ.get('TL_RTO_MS', '500')),
                       node_role=os.environ.get('TL_ROLE', 'initiator'),
                       mtu_bytes=int(os.environ.get('TL_MTU', '200')),
                       local_addr=int(os.environ.get('TL_LOCAL_ADDR', '0')),
                       local_port=int(os.environ.get('TL_LOCAL_PORT', '0')),
                       max_retries=int(os.environ.get('TL_MAX_RETRIES', '10'))):
              gr.sync_block.__init__(self, name="SR-ARQ FSM Core",
                                     in_sig=None, out_sig=None)
              assert node_role in ("initiator", "responder"), "TL_ROLE must be initiator or responder"
              assert 1 <= m <= 8,   "TL_M must be 1..8"
              assert mtu_bytes > 0, "TL_MTU must be > 0"
              self.m           = m
              self.seq_space   = 1 << m
              self.win_size    = 1 << (m - 1)
              self.rto_s       = rto_ms / 1000.0
              self.role        = node_role
              self.mtu         = mtu_bytes
              self.local_addr  = local_addr & 0xFF
              self.local_port  = local_port & 0xFF
              self.max_retries = max_retries
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("app_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("app_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu_in)
              self.set_msg_handler(pmt.intern("app_in"), self.handle_app_in)
              self._lock   = threading.Lock()
              self._timers = [None] * (self.seq_space + 1)
              self.last_done_sid = None
              self._reset_state()

          def _reset_state(self):
              self._cancel_all_timers()
              self.state = IDLE; self.session_id = 0
              self.dst_addr = 0; self.dst_port = 0
              self.ctrl_retries = 0; self.media_code = 0x00
              self.all_tx_pkts  = []
              self.tx_buf   = [None]  * self.seq_space
              self.acked    = [False] * self.seq_space
              self.data_retries = [0] * self.seq_space
              self.send_base = 0; self.next_seq_abs = 0; self.total_tx = 0
              self.rx_buf         = [None]  * self.seq_space
              self.received       = [False] * self.seq_space
              self.rcv_base = 0; self.total_rx = 0
              self.pkts_delivered = 0; self.reassembled = bytearray()

          def _start_timer(self, slot, timeout=None):
              self._cancel_timer(slot)
              t = threading.Timer(timeout or self.rto_s, self._on_timeout, args=[slot])
              t.daemon = True; self._timers[slot] = t; t.start()

          def _cancel_timer(self, slot):
              if self._timers[slot]:
                  self._timers[slot].cancel(); self._timers[slot] = None

          def _cancel_all_timers(self):
              if not hasattr(self, "_timers"): return
              for i in range(len(self._timers)): self._cancel_timer(i)

          def _on_timeout(self, slot):
              ctrl = self.seq_space
              with self._lock:
                  if slot == ctrl:
                      if self.state == SYN_SENT:
                          self.ctrl_retries += 1
                          if self.ctrl_retries > self.max_retries:
                              gr.log.error("FSM: SYN retry limit exceeded")
                              self._notify("tx_failed"); self._reset_state(); return
                          gr.log.warn(f"FSM: SYN RTO retry {self.ctrl_retries}/{self.max_retries}")
                          self._emit_ctrl(PKT_SYN, total_pkts=self.total_tx, media=self.media_code)
                          self._start_timer(ctrl)
                      elif self.state == FIN_SENT:
                          self.ctrl_retries += 1
                          if self.ctrl_retries > self.max_retries:
                              gr.log.warn("FSM: FIN retry limit exceeded")
                              self._notify("tx_done"); self._reset_state(); return
                          gr.log.warn(f"FSM: FIN RTO retry {self.ctrl_retries}/{self.max_retries}")
                          self._emit_ctrl(PKT_FIN)
                          self._start_timer(ctrl)
                      elif self.state in (SYN_RCVD, RX_ACTIVE):
                          gr.log.warn("FSM: peer went silent - abandoning RX session")
                          self._reset_state()
                  else:
                      if self.state == TX_ACTIVE and not self.acked[slot] and self.tx_buf[slot] is not None:
                          self.data_retries[slot] += 1
                          if self.data_retries[slot] > self.max_retries:
                              gr.log.error(f"FSM: DATA retry limit exceeded slot={slot}")
                              self._notify("tx_failed"); self._reset_state(); return
                          gr.log.warn(f"FSM: DATA RTO slot={slot}")
                          self._emit_data(slot); self._start_timer(slot)

          def handle_app_in(self, msg):
              if not pmt.is_pair(msg): return
              d = pmt.cdr(msg)
              if not pmt.is_u8vector(d): return
              frame = bytes(pmt.u8vector_elements(d))
              if len(frame) < 8:
                  gr.log.error("FSM app_in: frame too short"); return
              dst_addr, dst_port, type_byte, _ = struct.unpack_from(">BBBB", frame, 0)
              declared_len = struct.unpack_from(">I", frame, 4)[0]
              if len(frame) != 8 + declared_len:
                  gr.log.error("FSM app_in: length mismatch"); return
              with self._lock:
                  if self.state != IDLE:
                      gr.log.warn("FSM app_in: session active - dropping")
                      self._notify("tx_busy"); return
                  self.dst_addr = dst_addr & 0xFF; self.dst_port = dst_port & 0xFF
                  self.media_code = type_byte & 0xFF
                  self._packetize(frame)
                  self.session_id   = int.from_bytes(os.urandom(8), "big")
                  self.state        = SYN_SENT; self.ctrl_retries = 0
                  self._emit_ctrl(PKT_SYN, total_pkts=self.total_tx, media=self.media_code)
                  self._start_timer(self.seq_space)

          def handle_pdu_in(self, msg):
              if not pmt.is_pair(msg): return
              meta = pmt.car(msg); data = pmt.cdr(msg)
              if not pmt.is_dict(meta): return
              if not pmt.dict_has_key(meta, pmt.intern("pkt_type")): return
              pkt_str  = pmt.symbol_to_string(
                  pmt.dict_ref(meta, pmt.intern("pkt_type"), pmt.intern("")))
              pkt_code = PKT_CODE.get(pkt_str, 0)
              sid      = pmt.to_uint64(
                  pmt.dict_ref(meta, pmt.intern("session_id"), pmt.from_uint64(0)))
              payload  = bytes(pmt.u8vector_elements(data)) if pmt.is_u8vector(data) else b""
              def gu(k, d=0):
                  return pmt.to_uint64(pmt.dict_ref(meta, pmt.intern(k), pmt.from_uint64(d)))
              def gs(k, d=""):
                  return pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern(k), pmt.intern(d)))
              with self._lock:
                  if self.state != IDLE and pkt_code != PKT_SYN:
                      if sid != self.session_id: return
                  hdr = {"pkt_type":pkt_code, "media_type":MEDIA_CODE.get(gs("media_type"), 0),
                         "src_addr":gu("src_addr"), "src_port":gu("src_port"),
                         "dst_addr":gu("dst_addr"), "dst_port":gu("dst_port"),
                         "seq_no":gu("seq_no"), "total_pkts":gu("total_pkts"),
                         "session_id":sid}
                  dispatch = {IDLE:self._fsm_idle, SYN_SENT:self._fsm_syn_sent,
                              SYN_RCVD:self._fsm_syn_rcvd, TX_ACTIVE:self._fsm_tx_active,
                              RX_ACTIVE:self._fsm_rx_active, FIN_SENT:self._fsm_fin_sent}
                  if self.state in dispatch:
                      dispatch[self.state](hdr, payload)
                  if self.state in (SYN_RCVD, RX_ACTIVE):
                      self._start_timer(self.seq_space, self.rto_s * (self.max_retries + 2))

          def _fsm_idle(self, hdr, payload):
              if hdr["session_id"] == self.last_done_sid and hdr["pkt_type"] in (PKT_DATA, PKT_FIN):
                  self.session_id = hdr["session_id"]
                  self.dst_addr = hdr["src_addr"]; self.dst_port = hdr["src_port"]
                  if hdr["pkt_type"] == PKT_DATA: self._emit_ctrl(PKT_ACK, seq_no=hdr["seq_no"])
                  else:                           self._emit_ctrl(PKT_FIN_ACK)
                  self.session_id = 0; self.dst_addr = 0; self.dst_port = 0
                  return
              if hdr["pkt_type"] != PKT_SYN: return
              dst = hdr["dst_addr"]
              if self.local_addr != 0 and dst != 0 and dst != self.local_addr: return
              if self.local_port != 0 and hdr["dst_port"] != 0 and hdr["dst_port"] != self.local_port: return
              self.dst_addr=hdr["src_addr"]; self.dst_port=hdr["src_port"]
              self.session_id=hdr["session_id"]; self.total_rx=hdr["total_pkts"]
              self.media_code=hdr["media_type"]
              self.rcv_base=0; self.pkts_delivered=0; self.reassembled=bytearray()
              self.rx_buf=[None]*self.seq_space; self.received=[False]*self.seq_space
              self.state=SYN_RCVD; self._emit_ctrl(PKT_SYN_ACK)

          def _fsm_syn_sent(self, hdr, payload):
              if hdr["pkt_type"] != PKT_SYN_ACK: return
              self._cancel_timer(self.seq_space)
              self.state=TX_ACTIVE; self.send_base=0; self.next_seq_abs=0
              for _ in range(min(self.win_size, self.total_tx)):
                  slot=self.next_seq_abs % self.seq_space
                  self.tx_buf[slot]=self.all_tx_pkts[self.next_seq_abs]; self.acked[slot]=False; self.data_retries[slot]=0
                  self._emit_data(slot); self._start_timer(slot); self.next_seq_abs+=1

          def _fsm_syn_rcvd(self, hdr, payload):
              if hdr["pkt_type"]==PKT_SYN: self._emit_ctrl(PKT_SYN_ACK); return
              if hdr["pkt_type"]==PKT_DATA: self.state=RX_ACTIVE; self._fsm_rx_active(hdr, payload)

          def _fsm_tx_active(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_ACK: return
              seq=hdr["seq_no"]
              if self.acked[seq]: return
              self.acked[seq]=True; self._cancel_timer(seq); self._advance_window()

          def _fsm_rx_active(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_DATA: return
              seq=hdr["seq_no"]
              in_win=any(seq==(self.rcv_base+i)%self.seq_space for i in range(self.win_size))
              self._emit_ctrl(PKT_ACK, seq_no=seq)
              if not in_win: return
              if not self.received[seq]: self.received[seq]=True; self.rx_buf[seq]=payload
              self._try_deliver()

          def _fsm_fin_sent(self, hdr, payload):
              if hdr["pkt_type"]!=PKT_FIN_ACK: return
              self._cancel_timer(self.seq_space); self._notify("tx_done"); self._reset_state()

          def _advance_window(self):
              while self.send_base < self.total_tx and self.acked[self.send_base % self.seq_space]:
                  slot=self.send_base%self.seq_space
                  self.acked[slot]=False; self.tx_buf[slot]=None; self.send_base+=1
                  if self.next_seq_abs < self.total_tx:
                      ns=self.next_seq_abs%self.seq_space
                      self.tx_buf[ns]=self.all_tx_pkts[self.next_seq_abs]; self.acked[ns]=False; self.data_retries[ns]=0
                      self._emit_data(ns); self._start_timer(ns); self.next_seq_abs+=1
              if self.send_base >= self.total_tx:
                  self.state=FIN_SENT; self.ctrl_retries=0
                  self._emit_ctrl(PKT_FIN); self._start_timer(self.seq_space)

          def _try_deliver(self):
              while self.pkts_delivered < self.total_rx and self.received[self.rcv_base]:
                  self.reassembled.extend(self.rx_buf[self.rcv_base])
                  self.received[self.rcv_base]=False; self.rx_buf[self.rcv_base]=None
                  self.rcv_base=(self.rcv_base+1)%self.seq_space; self.pkts_delivered+=1
              if self.pkts_delivered == self.total_rx:
                  out=bytes(self.reassembled)
                  m=pmt.make_dict()
                  for k,v in [("payload_type",pmt.intern(MEDIA_STR.get(self.media_code,"unknown"))),
                              ("session_id",pmt.from_uint64(self.session_id)),
                              ("src_addr",pmt.from_uint64(self.dst_addr)),
                              ("src_port",pmt.from_uint64(self.dst_port)),
                              ("dst_addr",pmt.from_uint64(self.local_addr)),
                              ("dst_port",pmt.from_uint64(self.local_port))]:
                      m=pmt.dict_add(m, pmt.intern(k), v)
                  self.message_port_pub(pmt.intern("app_out"),
                      pmt.cons(m, pmt.init_u8vector(len(out), list(out))))
                  self._emit_ctrl(PKT_FIN_ACK)
                  self.last_done_sid = self.session_id
                  self._reset_state()

          def _notify(self, event):
              m = pmt.dict_add(pmt.make_dict(), pmt.intern("event"), pmt.intern(event))
              m = pmt.dict_add(m, pmt.intern("session_id"), pmt.from_uint64(self.session_id))
              # 1-byte dummy payload: an EMPTY u8vector crashes the C++ ZMQ sink's serializer
              # on distros built with _GLIBCXX_ASSERTIONS (Fedora): "Assertion '__n < this->size()'"
              self.message_port_pub(pmt.intern("app_out"), pmt.cons(m, pmt.init_u8vector(1, [0])))

          def _packetize(self, raw):
              self.all_tx_pkts=[raw[i:i+self.mtu] for i in range(0,len(raw),self.mtu)]
              self.tx_buf=[None]*self.seq_space; self.acked=[False]*self.seq_space
              self.total_tx=len(self.all_tx_pkts); self.send_base=0; self.next_seq_abs=0

          def _make_meta(self, pkt_code, seq_no=0, total_pkts=0, media=0):
              m=pmt.make_dict()
              for k,v in [("pkt_type",pmt.intern(PKT_STR.get(pkt_code,"UNKNOWN"))),
                          ("pkt_type_raw",pmt.from_uint64(pkt_code)),
                          ("seq_no",pmt.from_uint64(seq_no)),
                          ("total_pkts",pmt.from_uint64(total_pkts)),
                          ("media_type",pmt.intern(MEDIA_STR.get(media,"unknown"))),
                          ("media_raw",pmt.from_uint64(media)),
                          ("src_addr",pmt.from_uint64(self.local_addr)),
                          ("src_port",pmt.from_uint64(self.local_port)),
                          ("dst_addr",pmt.from_uint64(self.dst_addr)),
                          ("dst_port",pmt.from_uint64(self.dst_port)),
                          ("session_id",pmt.from_uint64(self.session_id))]:
                  m=pmt.dict_add(m, pmt.intern(k), v)
              return m

          def _emit_ctrl(self, pkt_code, seq_no=0, total_pkts=0, media=None):
              if media is None: media=self.media_code
              meta=self._make_meta(pkt_code, seq_no=seq_no, total_pkts=total_pkts, media=media)
              self.message_port_pub(pmt.intern("pdu_out"),
                  pmt.cons(meta, pmt.init_u8vector(0, [])))

          def _emit_data(self, slot):
              chunk=self.tx_buf[slot]
              if chunk is None: return
              meta=self._make_meta(PKT_DATA, seq_no=slot, total_pkts=self.total_tx, media=self.media_code)
              self.message_port_pub(pmt.intern("pdu_out"),
                  pmt.cons(meta, pmt.init_u8vector(len(chunk), list(chunk))))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 2: SR-ARQ FSM Core'
    local_addr: tl_local_addr
    local_port: tl_local_port
    m: tl_m
    max_retries: tl_max_retries
    mtu_bytes: tl_mtu
    node_role: tl_role
    rto_ms: tl_rto_ms
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import struct, pmt
      from gnuradio import gr

      HDR_FMT    = ">BBBBBBHHQ"
      PKT_CODE   = {"SYN":0x01, "SYN_ACK":0x02, "DATA":0x03,
                    "ACK":0x04, "FIN":0x05, "FIN_ACK":0x06}
      MEDIA_CODE = {"text":0x01, "image":0x02, "audio":0x03}


      class blk(gr.sync_block):
          """Block 3: TX Header Serializer -- stateless 18-byte binary header serializer."""

          def __init__(self):
              gr.sync_block.__init__(self, name='TX Header Serializer',
                                     in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle)

          def handle(self, msg):
              if not pmt.is_pair(msg): return
              meta = pmt.car(msg); data = pmt.cdr(msg)
              if not pmt.is_dict(meta): return
              def gu(k, d=0):
                  return pmt.to_uint64(pmt.dict_ref(meta, pmt.intern(k), pmt.from_uint64(d)))
              def gs(k, d=""):
                  return pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern(k), pmt.intern(d)))
              hdr = struct.pack(HDR_FMT,
                  PKT_CODE.get(gs("pkt_type"), 0),
                  MEDIA_CODE.get(gs("media_type"), 0),
                  gu("src_addr") & 0xFF, gu("src_port") & 0xFF,
                  gu("dst_addr") & 0xFF, gu("dst_port") & 0xFF,
                  gu("seq_no")    & 0xFFFF,
                  gu("total_pkts") & 0xFFFF,
                  gu("session_id"))
              payload  = bytes(pmt.u8vector_elements(data)) if pmt.is_u8vector(data) else b""
              frame    = hdr + payload
              out_data = pmt.init_u8vector(len(frame), list(frame))
              self.message_port_pub(pmt.intern("pdus"), pmt.cons(meta, out_data))

          def work(self, input_items, output_items):
              return 0
    comment: 'Block 3: TX Header Serializer'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Modular Exponentiation Encryption Block (PDU-based)
          cipher_byte = (plain_byte ** key) % prime          (prime must be 257)

      Placed between the ZMQ app source and the SR-ARQ FSM's app_in (application-layer,
      end-to-end encryption).
      - The first skip_bytes (8) bytes stay in clear: they are the app frame header
        [dst_addr][dst_port][media][reserved][length:4] that the FSM needs to route and size the
        transfer. Everything after it (file name + file data) is encrypted.
      - key must be odd (gcd(key, 256) == 1). Then x -> x^key mod 257 is a permutation of 0..255
        and the peer can invert it with private_key = key^-1 mod 256 (17 <-> 241, 3 <-> 171).
        key = 0 (the old PUBLIC_KEY_PEER default) maps every byte to 1 and destroys the data.
      - A 256-entry lookup table replaces the per-byte np.vectorize call.
      NOTE: this is a byte-substitution cipher for demonstration. Anyone who knows key and prime
      can compute the inverse, and byte frequencies are preserved, so it is not secure.
      """
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, prime=257, key=17, skip_bytes=8):
              gr.basic_block.__init__(self, name='Encrypt Payload', in_sig=None, out_sig=None)
              self.prime = prime
              self.key = key
              self.skip_bytes = skip_bytes
              self._lut_for = None
              self._lut = None
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.set_msg_handler(pmt.intern("pdus_in"), self.handle_pdu)

          def _table(self):
              cfg = (int(self.key), int(self.prime))
              if cfg != self._lut_for:
                  key, prime = cfg
                  if prime != 257:
                      print(f"[ENC] prime must be 257 for byte data (got {prime})", flush=True)
                  if key % 2 == 0:
                      print(f"[ENC] key {key} is even: it has no inverse mod 256, the receiver "
                            "cannot decrypt. Use an odd key (e.g. 17 or 3).", flush=True)
                  self._lut = np.array([pow(x, key, prime) & 0xFF for x in range(256)], dtype=np.uint8)
                  self._lut_for = cfg
              return self._lut

          def handle_pdu(self, pdu):
              if not pmt.is_pair(pdu) or not pmt.is_u8vector(pmt.cdr(pdu)):
                  return
              meta = pmt.car(pdu)
              data = np.array(pmt.u8vector_elements(pmt.cdr(pdu)), dtype=np.uint8)
              skip = max(0, int(self.skip_bytes))
              data[skip:] = self._table()[data[skip:]]
              out = pmt.init_u8vector(len(data), data.tolist())
              self.message_port_pub(pmt.intern("pdus_out"), pmt.cons(meta, out))
    comment: |-
      STAGE 3: encrypt app frames
      (header 8 B in clear)
    key: PUBLIC_KEY_PEER
    prime: PRIME
    skip_bytes: '8'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Modular Exponentiation Decryption Block (PDU-based)
          plain_byte = (cipher_byte ** private_key) % prime   (prime must be 257)

      Placed between the SR-ARQ FSM's app_out and the ZMQ app sink.
      - The first skip_bytes (8) bytes (app frame header) were never encrypted and are passed as-is.
      - FSM event messages (tx_done / tx_failed / tx_busy: metadata with an "event" key) are
        forwarded untouched.
      - private_key must be the inverse of the sender's key mod 256 (key 17 <-> 241, 3 <-> 171).
      """
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, prime=257, private_key=241, skip_bytes=8):
              gr.basic_block.__init__(self, name='Decrypt Payload', in_sig=None, out_sig=None)
              self.prime = prime
              self.private_key = private_key
              self.skip_bytes = skip_bytes
              self._lut_for = None
              self._lut = None
              self.message_port_register_in(pmt.intern("pdus_in"))
              self.message_port_register_out(pmt.intern("pdus_out"))
              self.set_msg_handler(pmt.intern("pdus_in"), self.handle_pdu)

          def _table(self):
              cfg = (int(self.private_key), int(self.prime))
              if cfg != self._lut_for:
                  d, prime = cfg
                  if prime != 257:
                      print(f"[DEC] prime must be 257 for byte data (got {prime})", flush=True)
                  self._lut = np.array([pow(x, d, prime) & 0xFF for x in range(256)], dtype=np.uint8)
                  self._lut_for = cfg
              return self._lut

          def handle_pdu(self, pdu):
              if not pmt.is_pair(pdu):
                  return
              meta, payload = pmt.car(pdu), pmt.cdr(pdu)
              if (pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern("event"))) \
                      or not pmt.is_u8vector(payload):
                  self.message_port_pub(pmt.intern("pdus_out"), pdu)      # FSM event: pass through
                  return
              data = np.array(pmt.u8vector_elements(payload), dtype=np.uint8)
              skip = max(0, int(self.skip_bytes))
              data[skip:] = self._table()[data[skip:]]
              out = pmt.init_u8vector(len(data), data.tolist())
              self.message_port_pub(pmt.intern("pdus_out"), pmt.cons(meta, out))
    comment: |-
      STAGE 3: decrypt app frames
      (events pass through)
    prime: PRIME
    private_key: PRIVATE_KEY
    skip_bytes: '8'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      """
      PDU Console Printer
      Prints each decrypted application frame from the FSM (skips FSM event messages).
      Long payloads are shortened to max_chars so a received image does not flood the console.
      """
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          def __init__(self, max_chars=120):
              gr.basic_block.__init__(self, name="PDU Payload Printer", in_sig=None, out_sig=None)
              self.max_chars = max_chars
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)

          def handle_pdu(self, pdu):
              if not pmt.is_pair(pdu):
                  return
              meta, payload_pmt = pmt.car(pdu), pmt.cdr(pdu)
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern("event")):
                  ev = pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern("event"), pmt.intern("?")))
                  print(f"[APP] FSM event: {ev}", flush=True)
                  return
              if not pmt.is_u8vector(payload_pmt):
                  return
              data = bytes(pmt.u8vector_elements(payload_pmt))
              body = data[8:]                       # after the 8-byte app frame header
              name = ""
              if len(body) >= 2:
                  nlen = int.from_bytes(body[:2], "big")
                  name = body[2:2 + nlen].decode("utf-8", errors="replace")
                  body = body[2 + nlen:]
              try:
                  shown = repr(body.decode("utf-8"))
              except UnicodeDecodeError:
                  shown = f"<binary {body[:24].hex()}...>"
              n = int(self.max_chars)
              if len(shown) > n:
                  shown = shown[:n] + "..."
              src = ""
              if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern("src_addr")):
                  src = f" from addr {pmt.to_python(pmt.dict_ref(meta, pmt.intern('src_addr'), pmt.PMT_NIL))}"
              print("\n" + "=" * 50, flush=True)
              print(f"[DECRYPTED PAYLOAD RECEIVED]{src}: '{name}' ({len(data)} bytes)", flush=True)
              print(f"  Content: {shown}", flush=True)
              print("=" * 50 + "\n", flush=True)
    max_chars: '120'
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: int(1.5e6)
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(1.5e6)
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: int(rx_freq)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: |-
      import os
      from gnuradio import zeromq
  states: {}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    comment: Unicast filter
    invert: 'False'
    k: pmt.intern("dst_addr")
    v: pmt.from_uint64(tl_local_addr)
  states: {}
- name: pdu_pdu_filter_0_0
  id: pdu_pdu_filter
  parameters:
    comment: Broadcast filter
    invert: 'False'
    k: pmt.intern("dst_addr")
    v: pmt.from_uint64(0)
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_tx
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    comment: |-
      STAGE 2: TX pulse shaping
      (replaces the BPSK modulator)
    gain: sps
    interp: sps
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: interp_fir_filter_ccf
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}
- name: zeromq_pub_sink_iq
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:" + str(iq_tx_port)'
    comment: 'SIM: replaces the Pluto sink'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://127.0.0.1:" + str(tl_zmq_tx_port)'
    bind: 'True'
    comment: Binds and receives from folder_sync_daemon PUSH (port tl_zmq_tx_port)
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://127.0.0.1:" + str(tl_zmq_rx_port)'
    comment: Binds and sends reassembled data to folder_sync_daemon PULL (port tl_zmq_rx_port)
    timeout: '100'
  states: {}
- name: zeromq_sub_source_iq
  id: zeromq_sub_source
  parameters:
    address: '"tcp://127.0.0.1:" + str(iq_rx_port)'
    comment: 'SIM: replaces the Pluto source'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', channels_channel_model_0, '0']
- [blocks_copy_0_0, '0', root_raised_cosine_filter_tx, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_5_0, '0']
- [blocks_tag_gate_0_0, '0', zeromq_pub_sink_iq, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [channels_channel_model_0, '0', digital_fll_band_edge_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, pdus, pdu_pdu_filter_0, pdus]
- [epy_block_0, pdus, pdu_pdu_filter_0_0, pdus]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [epy_block_0_0_0, link_out, epy_block_0_0, link_in]
- [epy_block_0_0_0, pdu_out, blocks_message_debug_0, print_pdu]
- [epy_block_0_0_0, pdu_out, epy_block_0, pdus]
- [epy_block_1, app_out, epy_block_4, pdus_in]
- [epy_block_1, pdu_out, epy_block_2, pdus]
- [epy_block_2, pdus, blocks_message_debug_1, print_pdu]
- [epy_block_2, pdus, epy_block_0_0, msg_in]
- [epy_block_3, pdus_out, epy_block_1, app_in]
- [epy_block_4, pdus_out, epy_block_5, pdu_in]
- [epy_block_4, pdus_out, zeromq_push_msg_sink_0, in]
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [pdu_pdu_filter_0, pdus, epy_block_1, pdu_in]
- [pdu_pdu_filter_0_0, pdus, epy_block_1, pdu_in]
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_tx, '0', blocks_tag_gate_0_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', blocks_copy_0_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', epy_block_0_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print_pdu]
- [zeromq_pull_msg_source_0, out, epy_block_3, pdus_in]
- [zeromq_sub_source_iq, '0', blocks_copy_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
