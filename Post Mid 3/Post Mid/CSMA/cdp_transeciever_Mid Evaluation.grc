options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: transeciever
    output_language: python
    title: 'CDP transeciever '
  states: {}

blocks:
- name: ADDR
  id: variable
  parameters:
    value: '"ip:192.168.1.10"'
  states: {}
- name: BPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[1+0j, -1+0j]'
    imag_sect: '1'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: CH_GAIN
  id: variable
  parameters:
    value: '20.0'
  states: {}
- name: MY_ID
  id: variable
  parameters:
    value: '0'
  states: {}
- name: QPSK_CONST
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: SDR_CF
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: adpt_alg
  id: variable_adaptive_algorithm
  parameters:
    cons: BPSK_CONST
    modulus: '4'
    step_size: '.01'
    type: cma
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: costas_bw
  id: variable
  parameters:
    value: '0.02'
  states: {}
- name: fll_loop_bw
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_bw
  id: variable
  parameters:
    value: '0.020'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '1000'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_copy_0_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_copy_1_1
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_1_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {}
- name: blocks_copy_2
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      used to skip head until 
      the filter settles.
    num_items: int(samp_rate)
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: QPSK_CONST
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSK_CONST
  states: {}
- name: digital_constellation_modulator_0_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK_CONST
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: BPSK_CONST.arity()
    w: costas_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11* sps +1
    improved_loop_filter: 'False'
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: fll_loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: adpt_alg
    num_taps: '15'
    sps: '2'
    training_sequence: '[]'
    training_start_tag: '""'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sym_bw
    max_dev: '0.05'
    osps: '2'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: CSMA/CA MAC Controller
      Monitors RX power (magnitude squared) and only allows PDUs to pass
      to the TX framer when the channel is clear.
      """
      import numpy as np
      import pmt
      import random
      from gnuradio import gr

      class CSMA_MAC(gr.sync_block):
          def __init__(self, cca_threshold=0.05, ifs_samples=15000, slot_samples=1500):
              gr.sync_block.__init__(
                  self,
                  name="CSMA MAC Controller",
                  in_sig=[np.float32], # RX signal magnitude squared
                  out_sig=None
              )
              self.cca_threshold = float(cca_threshold)
              self.ifs_samples = int(ifs_samples)
              self.slot_samples = int(slot_samples)
              
              self.tx_queue = []
              self.state = "IDLE" 
              self.idle_counter = 0
              self.backoff_counter = 0
              self.be = 1 # Backoff exponent
              
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("msg_out"))

          def handle_msg(self, msg):
              self.tx_queue.append(msg)

          def work(self, input_items, output_items):
              rx_power = input_items[0]
              n_samples = len(rx_power)
              
              # Bypass state machine entirely if there is nothing to transmit
              if not self.tx_queue:
                  return n_samples
                  
              is_busy_array = rx_power > self.cca_threshold
              
              for i in range(n_samples):
                  is_busy = is_busy_array[i]
                  
                  if self.state == "IDLE":
                      if self.tx_queue:
                          self.state = "IFS_WAIT"
                          self.idle_counter = 0
                  
                  elif self.state == "IFS_WAIT":
                      if is_busy:
                          self.idle_counter = 0
                          self.state = "BACKOFF_DRAW"
                      else:
                          self.idle_counter += 1
                          if self.idle_counter >= self.ifs_samples:
                              self._transmit()
                              
                  elif self.state == "BACKOFF_DRAW":
                      if not is_busy:
                          slots = random.randint(0, (1 << self.be) - 1)
                          self.backoff_counter = slots * self.slot_samples
                          self.state = "BACKOFF_WAIT"
                          
                  elif self.state == "BACKOFF_WAIT":
                      if is_busy:
                          self.state = "BACKOFF_FREEZE"
                      else:
                          if self.backoff_counter > 0:
                              self.backoff_counter -= 1
                          else:
                              self._transmit()
                              
                  elif self.state == "BACKOFF_FREEZE":
                      if not is_busy:
                          self.idle_counter += 1
                          if self.idle_counter >= self.ifs_samples:
                              self.idle_counter = 0
                              self.state = "BACKOFF_WAIT"
                      else:
                          self.idle_counter = 0
                          
              return n_samples

          def _transmit(self):
              if self.tx_queue:
                  msg = self.tx_queue.pop(0)
                  self.message_port_pub(pmt.intern("msg_out"), msg)
                  self.state = "IDLE"
    cca_threshold: ''
    ifs_samples: ''
    slot_samples: ''
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Burst Packet Framer TX
      - Outputs packed byte PDUs directly to pdu_pdu_to_tagged_stream
      - Zero idle transmission (idle between bursts = complete silence)
      - Zero postamble / trailing idle
      - Frame layout: [preamble] [1A CF FC 1D] [len: 2B][dest_id: 1B][msg_id: 1B][rep: 1B][n_reps: 1B] [payload] [CRC32: 4B]
      - CRC32 covers header + payload
      """
      import zlib
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])


      class PacketFramerTX(gr.basic_block):
          def __init__(self, peer_id=1, preamble_len=64, repeat_count=5, max_payload_len=1024, preamble_byte=0xFF):
              gr.basic_block.__init__(
                  self,
                  name="Packet Framer TX (Burst)",
                  in_sig=None,
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.preamble_len = int(preamble_len)
              self.repeat_count = int(repeat_count)
              self.max_payload_len = int(max_payload_len)
              self.preamble_byte = int(preamble_byte) & 0xFF
              self._msg_id = 0

              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.message_port_register_out(pmt.intern("pdu_out"))

          @staticmethod
          def _extract_payload(msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      return bytes(pmt.u8vector_elements(data))
                  return str(pmt.to_python(data)).encode("utf-8")
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg).encode("utf-8")
              val = pmt.to_python(msg)
              if isinstance(val, (bytes, bytearray)):
                  return bytes(val)
              return str(val).encode("utf-8")

          def handle_msg(self, msg):
              try:
                  payload = self._extract_payload(msg)
              except Exception as e:
                  print(f"[TX] Could not parse message: {e}", flush=True)
                  return

              if not payload:
                  return

              if len(payload) > self.max_payload_len:
                  print(f"[TX] Payload {len(payload)} B truncated to {self.max_payload_len} B", flush=True)
                  payload = payload[:self.max_payload_len]

              msg_id = self._msg_id
              self._msg_id = (self._msg_id + 1) & 0xFF
              n_reps = max(1, min(255, self.repeat_count))

              preamble = bytes([self.preamble_byte]) * self.preamble_len
              print(f"[TX] msg #{msg_id} (to peer {self.peer_id}): '{payload.decode('utf-8', 'replace')}' ({n_reps} bursts queued)", flush=True)

              for rep in range(n_reps):
                  header = len(payload).to_bytes(2, "big") + bytes([self.peer_id, msg_id, rep, n_reps])
                  crc = zlib.crc32(header + payload).to_bytes(4, "big")
                  frame = preamble + SYNC_WORD + header + payload + crc

                  vec = pmt.init_u8vector(len(frame), list(frame))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(pmt.PMT_NIL, vec))
    max_payload_len: '8196'
    peer_id: '1'
    preamble_byte: '0xFF'
    preamble_len: '1024'
    repeat_count: '50'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Block: Fast Burst Packet Deframer RX
      - Vectorized NumPy sliding-window sync detection (fast C execution, minimal GIL load)
      - Positive correlation search only (180-deg phase ambiguity resolved upstream by diff decoder)
      - 1-bit false sync backtracking (prevents dropped frames on noise triggers)
      - Full CRC32 verification over header + payload
      - Destination address filtering: drops frames where dest_id != peer_id
      - Message deduplication: displays payload once per msg_id, then logs burst statistics
      """
      import zlib
      import numpy as np
      import pmt
      from gnuradio import gr

      SYNC_WORD = bytes([0x1A, 0xCF, 0xFC, 0x1D])
      HDR_BYTES = 6  # len (2B) + dest_id (1B) + msg_id (1B) + rep (1B) + n_reps (1B)


      class PacketDeframerRX(gr.sync_block):
          def __init__(self, peer_id=1, max_bit_errors=2, max_payload_len=1024, bit_rate=375000):
              gr.sync_block.__init__(
                  self,
                  name="Packet Deframer RX (Fast Burst)",
                  in_sig=[np.uint8],
                  out_sig=None,
              )
              self.peer_id = int(peer_id) & 0xFF
              self.max_bit_errors = int(max_bit_errors)
              self.max_payload_len = int(max_payload_len)
              self.bit_rate = float(bit_rate)

              # Bipolar template (+1 / -1) for correlation
              self._sync = np.unpackbits(np.frombuffer(SYNC_WORD, np.uint8)).astype(np.int16) * 2 - 1
              self._buf = np.zeros(0, dtype=np.uint8)

              self.n_sync = 0
              self.n_ok = 0
              self.n_crc_fail = 0
              self.n_bad_len = 0

              self._bits_total = 0
              self._bits_at_last_ok = 0
              self._cur_id = None
              self._cur_reps = set()
              self._cur_nreps = 0

              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("text_out"))

          def _flush_summary(self):
              if self._cur_id is not None:
                  got, n = len(self._cur_reps), self._cur_nreps
                  loss = 100.0 * (n - got) / max(n, 1)
                  print(f"[RX] msg #{self._cur_id}: {got}/{n} bursts OK (Loss: {loss:.0f}%)", flush=True)
              self._cur_id = None
              self._cur_reps = set()

          def _deliver(self, header, payload):
              dest_id, msg_id, rep, n_reps = header[2], header[3], header[4], header[5]
              if msg_id != self._cur_id:
                  self._flush_summary()
                  self._cur_id, self._cur_nreps = msg_id, n_reps
                  text = payload.decode("utf-8", errors="replace")
                  print("\n" + "=" * 40, flush=True)
                  print(f"[RX RECEIVED] #{msg_id}: {text}", flush=True)
                  print("=" * 40 + "\n", flush=True)

                  meta = pmt.make_dict()
                  meta = pmt.dict_add(meta, pmt.intern("dest_id"), pmt.from_long(dest_id))
                  meta = pmt.dict_add(meta, pmt.intern("msg_id"), pmt.from_long(msg_id))
                  meta = pmt.dict_add(meta, pmt.intern("n_reps"), pmt.from_long(n_reps))
                  vec = pmt.init_u8vector(len(payload), list(payload))
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, vec))
                  self.message_port_pub(pmt.intern("text_out"), pmt.intern(text))

              self._cur_reps.add(rep)
              self._bits_at_last_ok = self._bits_total

          def work(self, input_items, output_items):
              bits = input_items[0] & 1
              self._bits_total += len(bits)
              self._buf = np.concatenate((self._buf, bits)) if len(self._buf) else bits.copy()

              # Flush transmission stats once channel has been quiet for > 0.5s of air time
              if self._cur_id is not None and self._bits_total - self._bits_at_last_ok > 0.5 * self.bit_rate:
                  self._flush_summary()

              thr = 32 - 2 * self.max_bit_errors
              hdr_bits = 32 + HDR_BYTES * 8

              while True:
                  buf = self._buf
                  if len(buf) < hdr_bits:
                      return len(bits)

                  # Fast matrix dot product over 32-bit window (only positive peaks)
                  pm = buf.astype(np.int16) * 2 - 1
                  corr = np.lib.stride_tricks.sliding_window_view(pm, 32) @ self._sync
                  cand = np.flatnonzero(corr >= thr)

                  if cand.size == 0:
                      self._buf = buf[-31:].copy()  # Preserve trailing bits that might begin a sync word
                      return len(bits)

                  i = int(cand[0])

                  if len(buf) < i + hdr_bits:
                      self._buf = buf[i:].copy()  # Await complete header bits
                      return len(bits)

                  header = np.packbits(buf[i + 32 : i + hdr_bits]).tobytes()
                  length = int.from_bytes(header[:2], "big")

                  if length == 0 or length > self.max_payload_len:
                      self.n_bad_len += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync
                      continue

                  end = i + 32 + (HDR_BYTES + length + 4) * 8
                  if len(buf) < end:
                      self._buf = buf[i:].copy()  # Await complete frame body bits
                      return len(bits)

                  body = np.packbits(buf[i + 32 : end]).tobytes()
                  hdr, payload, rx_crc = body[:HDR_BYTES], body[HDR_BYTES : HDR_BYTES + length], body[-4:]
                  self.n_sync += 1

                  if zlib.crc32(hdr + payload) == int.from_bytes(rx_crc, "big"):
                      dest_id = hdr[2]
                      if dest_id == self.peer_id:
                          self.n_ok += 1
                          self._deliver(hdr, payload)
                      # Frame addressed to another peer: discard silently
                      self._buf = buf[end:].copy()  # Advance past valid frame
                  else:
                      self.n_crc_fail += 1
                      self._buf = buf[i + 1:].copy()  # Backtrack 1 bit past false sync

              return len(bits)
    bit_rate: '375000'
    max_bit_errors: '1'
    max_payload_len: '8192'
    peer_id: MY_ID
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: CH_GAIN
    bandwidth: '20000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(500e6)
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '4096'
    filter_source: '''Auto'''
    frequency: int(733e6)
    gain1: '''manual'''
    manual_gain1: '45'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: ADDR
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: '"TX Message"'
    type: string
    value: '"MESSAGE"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '1'
    ntaps: 11*sps+1
    samp_rate: samp_rate
    sym_rate: samp_rate/float(sps)
    type: fir_filter_ccf
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    bufflen: '4096'
    center_freq: SDR_CF
    gain: CH_GAIN
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {state: disabled}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: freq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: packet_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: decoded_constallation
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: decoded_stream
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: freq
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_copy_1, '0']
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_0_0, '0']
- [blocks_copy_0_0, '0', digital_constellation_modulator_0_1, '0']
- [blocks_copy_1, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_1_0, '0', blocks_copy_1, '0']
- [blocks_copy_1_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_copy_1_1, '0', analog_agc_xx_0, '0']
- [blocks_copy_1_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_copy_1_1, '0', blocks_copy_1_0, '0']
- [blocks_copy_1_2, '0', root_raised_cosine_filter_0, '0']
- [blocks_copy_2, '0', digital_costas_loop_cc_0, '0']
- [blocks_skiphead_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_tag_gate_0_0, '0', iio_pluto_sink_0_0, '0']
- [blocks_tag_gate_0_0, '0', virtual_sink_5_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_2_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_modulator_0_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_tag_gate_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_copy_1_2, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_copy_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0, '0']
- [epy_block_0, msg_out, epy_block_0_0, msg_in]
- [epy_block_0_0, pdu_out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [iio_pluto_source_0, '0', blocks_copy_1_1, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', virtual_sink_0_1, '0']
- [qtgui_edit_box_msg_0_0, msg, epy_block_0, msg_in]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_copy_1_1, '0']
- [virtual_source_0_0_0, '0', blocks_copy_0_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_0_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2_0, '0', epy_block_0_0_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
