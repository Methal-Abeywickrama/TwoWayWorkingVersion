options:
  parameters:
    author: mushab404
    generate_options: qt_gui
    id: compression
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os
      import site
      import sys
      import pmt
      import numpy as np
      from gnuradio import gr

      # Load user site packages dynamically
      possible_paths = site.getusersitepackages()
      if isinstance(possible_paths, str):
          possible_paths = [possible_paths]
      for path in possible_paths + site.getsitepackages():
          if os.path.exists(path) and path not in sys.path:
              sys.path.insert(0, path)

      import zstandard as zstd

      class pdu_zstd_compressor(gr.basic_block):
          """
          Compresses incoming PDU payloads using Zstandard and dictionary.
          """
          def __init__(self, dict_path="chat_dictionary.zdict"):
              gr.basic_block.__init__(
                  self,
                  name="PDU Zstd Compressor",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)

              base_dir = os.getcwd()
              resolved_dict_path = os.path.join(base_dir, dict_path)

              if os.path.exists(resolved_dict_path):
                  with open(resolved_dict_path, "rb") as f:
                      dictionary = zstd.ZstdCompressionDict(f.read())
                  self.compressor = zstd.ZstdCompressor(dict_data=dictionary)
              else:
                  self.compressor = zstd.ZstdCompressor()

          def handle_pdu(self, pdu):
              meta = pmt.car(pdu)
              data_vector = pmt.cdr(pdu)
              
              raw_bytes = bytes(pmt.u8vector_elements(data_vector))
              compressed_bytes = self.compressor.compress(raw_bytes)
              
              out_data = pmt.init_u8vector(len(compressed_bytes), list(compressed_bytes))
              out_pdu = pmt.cons(meta, out_data)
              
              self.message_port_pub(pmt.intern("pdu_out"), out_pdu)
    dict_path: '''chat_dictionary.zdict'''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import os
      import site
      import sys
      import pmt
      import numpy as np
      from gnuradio import gr

      # --- DYNAMIC PORTABLE PATH FIX ---
      possible_paths = site.getusersitepackages()
      if isinstance(possible_paths, str):
          possible_paths = [possible_paths]

      for path in possible_paths + site.getsitepackages():
          if os.path.exists(path) and path not in sys.path:
              sys.path.insert(0, path)

      import zstandard as zstd


      class pdu_zstd_decompressor(gr.basic_block):
          """
          Decompresses incoming Zstandard PDU payloads using a dictionary.
          Inputs and outputs asynchronously via PDU message ports.
          """

          def __init__(self, dict_path="chat_dictionary.zdict"):
              gr.basic_block.__init__(
                  self,
                  name="PDU Zstd Decompressor",
                  in_sig=None,
                  out_sig=None,
              )

              # Register PDU message ports
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)

              # Resolve dictionary relative to execution directory
              base_dir = os.getcwd()
              resolved_dict_path = os.path.join(base_dir, dict_path)

              if os.path.exists(resolved_dict_path):
                  with open(resolved_dict_path, "rb") as f:
                      dictionary = zstd.ZstdCompressionDict(f.read())
                  self.decompressor = zstd.ZstdDecompressor(dict_data=dictionary)
              elif os.path.exists(dict_path):
                  with open(dict_path, "rb") as f:
                      dictionary = zstd.ZstdCompressionDict(f.read())
                  self.decompressor = zstd.ZstdDecompressor(dict_data=dictionary)
              else:
                  # Fallback if no dictionary is found
                  self.decompressor = zstd.ZstdDecompressor()

          def handle_pdu(self, pdu):
              # Extract metadata dictionary and uniform 8-bit vector payload
              meta = pmt.car(pdu)
              data_vector = pmt.cdr(pdu)

              try:
                  # Extract raw compressed bytes
                  compressed_bytes = bytes(pmt.u8vector_elements(data_vector))

                  # Decompress using zstd
                  decompressed_bytes = self.decompressor.decompress(compressed_bytes)

                  # Re-wrap decompressed bytes into PMT byte vector PDU
                  out_data = pmt.init_u8vector(
                      len(decompressed_bytes), list(decompressed_bytes)
                  )
                  out_pdu = pmt.cons(meta, out_data)

                  # Publish decompressed message packet
                  self.message_port_pub(pmt.intern("pdu_out"), out_pdu)

              except Exception as e:
                  # Safely log corrupted or un-decompressable packets over noisy radio channels
                  sys.stderr.write(f"[PDU Decompressor Error]: {e}\n")
    dict_path: '''chat_dictionary.zdict'''
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import sys, os
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="Path Checker", in_sig=None, out_sig=None)
              print("GRC Python Executable:", sys.executable)
              print("GRC sys.path:", sys.path)
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import os
      import site
      import sys
      import json
      import time
      import numpy as np
      import pmt
      from gnuradio import gr

      class pdu_chat_generator(gr.basic_block):
          """
          Generates JSON chat message PDUs. Accepts custom strings from QT Message Edit Box.
          """
          def __init__(self, sender_id="A", recipient_id="B"):
              gr.basic_block.__init__(
                  self,
                  name="PDU Chat Generator",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_in(pmt.intern("generate"))
              self.set_msg_handler(pmt.intern("generate"), self.handle_generate)

              self.sender_id = sender_id
              self.recipient_id = recipient_id
              self.msg_counter = 0

          def handle_generate(self, msg):
              text_content = "Default Message"

              # Check if incoming message is a PMT Pair (from QT Message Edit Box)
              if pmt.is_pair(msg):
                  # Extract value from key-value pair ('mes' . 'MESSAGE')
                  val = pmt.cdr(msg)
                  if pmt.is_symbol(val):
                      text_content = pmt.symbol_to_string(val)
                  elif pmt.is_string(val):
                      text_content = pmt.symbol_to_string(val)
              # Check if incoming message is a plain string/symbol
              elif pmt.is_symbol(msg):
                  text_content = pmt.symbol_to_string(msg)
              elif pmt.is_string(msg):
                  text_content = pmt.symbol_to_string(msg)

              # Build JSON using your custom typed string
              self.msg_counter += 1
              payload = {
                  "sender": self.sender_id,
                  "recipient": self.recipient_id,
                  "msg_id": self.msg_counter,
                  "timestamp": int(time.time()),
                  "type": "text",
                  "content": text_content
              }

              # Encode to compact JSON byte string
              json_bytes = json.dumps(payload, separators=(',', ':')).encode('utf-8')

              # Create PDU: metadata dict + byte array vector
              meta = pmt.make_dict()
              data = pmt.init_u8vector(len(json_bytes), list(json_bytes))
              pdu = pmt.cons(meta, data)

              # Publish compressed pipeline input
              self.message_port_pub(pmt.intern("pdu_out"), pdu)
    recipient_id: '"B"'
    sender_id: '"A"'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: mes
    label: mes
    type: string
    value: MESSAGE
  states: {}

connections:
- [epy_block_0, pdu_out, epy_block_1, pdu_in]
- [epy_block_1, pdu_out, blocks_message_debug_0, print]
- [epy_block_3, pdu_out, epy_block_0, pdu_in]
- [qtgui_edit_box_msg_0, msg, epy_block_3, generate]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
